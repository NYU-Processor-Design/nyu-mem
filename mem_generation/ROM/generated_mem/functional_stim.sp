* Functional test stimulus file for 10ns period

* TT process corner
.include "/Users/seandoyle/NYU/classes/ProcessorDesign/openram/technology/scn4m_subm/models/nom/pmos.sp"
.include "/Users/seandoyle/NYU/classes/ProcessorDesign/openram/technology/scn4m_subm/models/nom/nmos.sp"
.include "ROM_Mem.sp"

* Global Power Supplies
Vvdd vdd 0 3.3

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
XROM_Mem din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 a0_0 a0_1 a0_2 a0_3 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 vdd gnd ROM_Mem

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f

* Important signals for debug
* bl:	xrom_mem.xbank0.bl_0_0
* br:	xrom_mem.xbank0.br_0_0
* s_en:	xrom_mem.s_en
* q:	xROM_Mem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xROM_Mem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 11111011  to  address 0000 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 01010010  to  address 1110 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 10110000  to  address 1110 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 11111011 from address 0000 (from port 0) during cycle 4 (40ns - 50ns)
*	Writing 11011110  to  address 0000 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 10110000 from address 1110 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 7 (70ns - 80ns)
*	Writing 00001111  to  address 1110 (from port 0) during cycle 10 (100ns - 110ns)
*	Writing 01011010  to  address 1110 (from port 0) during cycle 12 (120ns - 130ns)
*	Writing 11011011  to  address 1110 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 11011011 from address 1110 (from port 0) during cycle 16 (160ns - 170ns)
*	Reading 11011011 from address 1110 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 21 (210ns - 220ns)
*	Writing 11110000  to  address 1110 (from port 0) during cycle 22 (220ns - 230ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 11110000 from address 1110 (from port 0) during cycle 25 (250ns - 260ns)
*	Reading 11011110 from address 0000 (from port 0) during cycle 26 (260ns - 270ns)
*	Writing 10010011  to  address 0000 (from port 0) during cycle 28 (280ns - 290ns)
*	Writing 00100010  to  address 1110 (from port 0) during cycle 30 (300ns - 310ns)
*	Reading 00100010 from address 1110 (from port 0) during cycle 31 (310ns - 320ns)
*	Reading 00100010 from address 1110 (from port 0) during cycle 33 (330ns - 340ns)
*	Reading 10010011 from address 0000 (from port 0) during cycle 34 (340ns - 350ns)
*	Reading 00100010 from address 1110 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 10010011 from address 0000 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing 00000100  to  address 0000 (from port 0) during cycle 38 (380ns - 390ns)
*	Writing 01001100  to  address 1110 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 00000100 from address 0000 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 00000100 from address 0000 (from port 0) during cycle 41 (410ns - 420ns)
*	Writing 01001110  to  address 0000 (from port 0) during cycle 43 (430ns - 440ns)
*	Reading 01001100 from address 1110 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 11000010  to  address 1110 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 01001110 from address 0000 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 48 (480ns - 490ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 49 (490ns - 500ns)
*	Reading 01001110 from address 0000 (from port 0) during cycle 50 (500ns - 510ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 53 (530ns - 540ns)
*	Writing 01100100  to  address 0000 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 01100100 from address 0000 (from port 0) during cycle 55 (550ns - 560ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 57 (570ns - 580ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 58 (580ns - 590ns)
*	Reading 01100100 from address 0000 (from port 0) during cycle 60 (600ns - 610ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 63 (630ns - 640ns)
*	Reading 11000010 from address 1110 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing 11011100  to  address 1110 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 66 (660ns - 670ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 67 (670ns - 680ns)
*	Reading 01100100 from address 0000 (from port 0) during cycle 69 (690ns - 700ns)
*	Writing 01100110  to  address 0000 (from port 0) during cycle 70 (700ns - 710ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 74 (740ns - 750ns)
*	Writing 10100111  to  address 0000 (from port 0) during cycle 75 (750ns - 760ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 76 (760ns - 770ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 79 (790ns - 800ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 80 (800ns - 810ns)
*	Writing 00011111  to  address 1110 (from port 0) during cycle 81 (810ns - 820ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 82 (820ns - 830ns)
*	Reading 00011111 from address 1110 (from port 0) during cycle 83 (830ns - 840ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 85 (850ns - 860ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 86 (860ns - 870ns)
*	Writing 10000010  to  address 1110 (from port 0) during cycle 88 (880ns - 890ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 89 (890ns - 900ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 91 (910ns - 920ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 93 (930ns - 940ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 94 (940ns - 950ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 99 (990ns - 1000ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Writing 11101000  to  address 1110 (from port 0) during cycle 102 (1020ns - 1030ns)
*	Reading 10100111 from address 0000 (from port 0) during cycle 103 (1030ns - 1040ns)
*	Writing 00011111  to  address 0000 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 00011111 from address 0000 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Writing 00111101  to  address 1110 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 00111101 from address 1110 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Writing 01001100  to  address 1110 (from port 0) during cycle 111 (1110ns - 1120ns)
*	Reading 01001100 from address 1110 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Reading 01001100 from address 1110 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 01001100 from address 1110 (from port 0) during cycle 115 (1150ns - 1160ns)
*	Writing 10100111  to  address 1110 (from port 0) during cycle 116 (1160ns - 1170ns)
*	Writing 11110010  to  address 0000 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Reading 10100111 from address 1110 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Reading 11110010 from address 0000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Reading 10100111 from address 1110 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Reading 10100111 from address 1110 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Writing 00001000  to  address 1110 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Writing 10110111  to  address 0000 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing 01000100  to  address 0000 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 01000100 from address 0000 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 01000100 from address 0000 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Writing 10010101  to  address 0000 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Writing 11001111  to  address 0000 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 00001000 from address 1110 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Reading 00001000 from address 1110 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Writing 11100111  to  address 0000 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 00001000 from address 1110 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 00001000 from address 1110 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Reading 00001000 from address 1110 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Writing 10111111  to  address 0000 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Writing 01110011  to  address 1110 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 10111111 from address 0000 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 10111111 from address 0000 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 10111111 from address 0000 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 01110011 from address 1110 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 10111111 from address 0000 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Writing 10110000  to  address 0000 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Writing 01011000  to  address 1110 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Writing 00001101  to  address 0000 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Writing 00111111  to  address 1110 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Reading 00111111 from address 1110 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 01100100  to  address 1110 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Reading 01100100 from address 1110 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Reading 01100100 from address 1110 (from port 0) during cycle 159 (1590ns - 1600ns)
*	Reading 00001101 from address 0000 (from port 0) during cycle 162 (1620ns - 1630ns)
*	Writing 00100111  to  address 1110 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Reading 00001101 from address 0000 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Writing 00001101  to  address 0000 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 00001101 from address 0000 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 00001101 from address 0000 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Reading 00001101 from address 0000 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Reading 00100111 from address 1110 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Writing 11101000  to  address 1110 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Reading 11101000 from address 1110 (from port 0) during cycle 178 (1780ns - 1790ns)
*	Writing 01100000  to  address 1110 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Writing 11111110  to  address 0000 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Writing 10001011  to  address 1110 (from port 0) during cycle 182 (1820ns - 1830ns)
*	Writing 11011111  to  address 1110 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Writing 10011001  to  address 1110 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Writing 01010111  to  address 1110 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 188 (1880ns - 1890ns)
*	Reading 11111110 from address 0000 (from port 0) during cycle 192 (1920ns - 1930ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Writing 10100100  to  address 0000 (from port 0) during cycle 194 (1940ns - 1950ns)
*	Writing 00010011  to  address 0000 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Writing 10011100  to  address 1110 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing 11111011  to  address 0000 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 11111011 from address 0000 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 1), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 1), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 0), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 0), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 0), (1550, 0), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 1), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 1), (1950, 1), (1960, 0), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 3.3v 69.45n 3.3v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 0.0v 349.45n 0.0v 349.55n 3.3v 359.45n 3.3v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 0.0v 829.45n 0.0v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 0.0v 939.45n 0.0v 939.55n 3.3v 949.45n 3.3v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 3.3v 69.45n 3.3v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 0.0v 349.45n 0.0v 349.55n 3.3v 359.45n 3.3v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 0.0v 829.45n 0.0v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 0.0v 939.45n 0.0v 939.55n 3.3v 949.45n 3.3v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 0), (50, 0), (60, 1), (70, 0), (80, 0), (90, 0), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 0), (220, 1), (230, 1), (240, 0), (250, 1), (260, 0), (270, 0), (280, 0), (290, 0), (300, 1), (310, 1), (320, 1), (330, 1), (340, 0), (350, 1), (360, 0), (370, 0), (380, 0), (390, 1), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 1), (460, 1), (470, 0), (480, 1), (490, 1), (500, 0), (510, 0), (520, 0), (530, 1), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 1), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 0), (800, 0), (810, 1), (820, 0), (830, 1), (840, 1), (850, 0), (860, 0), (870, 0), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 0), (940, 1), (950, 0), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 0), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 1), (1500, 1), (1510, 0), (1520, 0), (1530, 1), (1540, 0), (1550, 1), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 0), (1630, 1), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 0), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 1), (1940, 0), (1950, 0), (1960, 0), (1970, 1), (1980, 1), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 3.3v 69.45n 3.3v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 0.0v 219.45n 0.0v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 0.0v 349.45n 0.0v 349.55n 3.3v 359.45n 3.3v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 3.3v 399.45n 3.3v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 0.0v 829.45n 0.0v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 0.0v 939.45n 0.0v 939.55n 3.3v 949.45n 3.3v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 1), (90, 1), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 0), (270, 1), (280, 0), (290, 1), (300, 0), (310, 0), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 0), (390, 0), (400, 0), (410, 0), (420, 1), (430, 0), (440, 1), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 0), (540, 0), (550, 0), (560, 1), (570, 0), (580, 0), (590, 1), (600, 0), (610, 1), (620, 1), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 0), (700, 0), (710, 0), (720, 1), (730, 1), (740, 0), (750, 0), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 0), (860, 0), (870, 1), (880, 0), (890, 0), (900, 0), (910, 0), (920, 1), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 1), (990, 0), (1000, 1), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 1), (1150, 0), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 1), (1610, 1), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 0), (1890, 1), (1900, 1), (1910, 1), (1920, 0), (1930, 0), (1940, 0), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 3.3v 279.45n 3.3v 279.55n 0.0v 289.45n 0.0v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 3.3v 429.45n 3.3v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 3.3v 569.45n 3.3v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 3.3v 599.45n 3.3v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 3.3v 849.45n 3.3v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 3.3v 929.45n 3.3v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 3.3v 989.45n 3.3v 989.55n 0.0v 999.45n 0.0v 999.55n 3.3v 1009.45n 3.3v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 0), (60, 1), (70, 1), (80, 1), (90, 1), (100, 0), (110, 1), (120, 0), (130, 1), (140, 1), (150, 0), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 0), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 0), (290, 1), (300, 0), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 0), (390, 0), (400, 1), (410, 1), (420, 1), (430, 0), (440, 1), (450, 1), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 0), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 1), (690, 1), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 0), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 0), (1030, 1), (1040, 1), (1050, 0), (1060, 1), (1070, 1), (1080, 1), (1090, 0), (1100, 1), (1110, 0), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 0), (1170, 1), (1180, 1), (1190, 1), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 0), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 0), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 1), (1420, 0), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 0), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 0), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 0), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 0), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 0), (1950, 1), (1960, 0), (1970, 0), (1980, 1), (1990, 0), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 3.3v 49.45n 3.3v 49.55n 0.0v 59.45n 0.0v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 0.0v 159.45n 0.0v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 0.0v 229.45n 0.0v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 0.0v 289.45n 0.0v 289.55n 3.3v 299.45n 3.3v 299.55n 0.0v 309.45n 0.0v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 0.0v 549.45n 0.0v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 0.0v 819.45n 0.0v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 0.0v 889.45n 0.0v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 3.3 9.95n 0.1n 0.1n 4.9n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 3.3 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 3.3 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 3.3 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 3.3 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 3.3 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 3.3 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 3.3 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 70
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=70.05n

* CHECK dout0_1 Vdout0_1ck6 = 0 time = 70
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=70.05n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 70
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=70.05n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 70
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=70.05n

* CHECK dout0_4 Vdout0_4ck6 = 3.3 time = 70
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=70.05n

* CHECK dout0_5 Vdout0_5ck6 = 3.3 time = 70
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=70.05n

* CHECK dout0_6 Vdout0_6ck6 = 0 time = 70
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=70.05n

* CHECK dout0_7 Vdout0_7ck6 = 3.3 time = 70
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=70.05n

* CHECK dout0_0 Vdout0_0ck7 = 0 time = 80
.meas tran vdout0_0ck7 FIND v(dout0_0) AT=80.05n

* CHECK dout0_1 Vdout0_1ck7 = 3.3 time = 80
.meas tran vdout0_1ck7 FIND v(dout0_1) AT=80.05n

* CHECK dout0_2 Vdout0_2ck7 = 3.3 time = 80
.meas tran vdout0_2ck7 FIND v(dout0_2) AT=80.05n

* CHECK dout0_3 Vdout0_3ck7 = 3.3 time = 80
.meas tran vdout0_3ck7 FIND v(dout0_3) AT=80.05n

* CHECK dout0_4 Vdout0_4ck7 = 3.3 time = 80
.meas tran vdout0_4ck7 FIND v(dout0_4) AT=80.05n

* CHECK dout0_5 Vdout0_5ck7 = 0 time = 80
.meas tran vdout0_5ck7 FIND v(dout0_5) AT=80.05n

* CHECK dout0_6 Vdout0_6ck7 = 3.3 time = 80
.meas tran vdout0_6ck7 FIND v(dout0_6) AT=80.05n

* CHECK dout0_7 Vdout0_7ck7 = 3.3 time = 80
.meas tran vdout0_7ck7 FIND v(dout0_7) AT=80.05n

* CHECK dout0_0 Vdout0_0ck16 = 3.3 time = 170
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=170.05n

* CHECK dout0_1 Vdout0_1ck16 = 3.3 time = 170
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=170.05n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 170
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=170.05n

* CHECK dout0_3 Vdout0_3ck16 = 3.3 time = 170
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=170.05n

* CHECK dout0_4 Vdout0_4ck16 = 3.3 time = 170
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=170.05n

* CHECK dout0_5 Vdout0_5ck16 = 0 time = 170
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=170.05n

* CHECK dout0_6 Vdout0_6ck16 = 3.3 time = 170
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=170.05n

* CHECK dout0_7 Vdout0_7ck16 = 3.3 time = 170
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=170.05n

* CHECK dout0_0 Vdout0_0ck20 = 3.3 time = 210
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=210.05n

* CHECK dout0_1 Vdout0_1ck20 = 3.3 time = 210
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=210.05n

* CHECK dout0_2 Vdout0_2ck20 = 0 time = 210
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=210.05n

* CHECK dout0_3 Vdout0_3ck20 = 3.3 time = 210
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=210.05n

* CHECK dout0_4 Vdout0_4ck20 = 3.3 time = 210
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=210.05n

* CHECK dout0_5 Vdout0_5ck20 = 0 time = 210
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=210.05n

* CHECK dout0_6 Vdout0_6ck20 = 3.3 time = 210
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=210.05n

* CHECK dout0_7 Vdout0_7ck20 = 3.3 time = 210
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=210.05n

* CHECK dout0_0 Vdout0_0ck21 = 0 time = 220
.meas tran vdout0_0ck21 FIND v(dout0_0) AT=220.05n

* CHECK dout0_1 Vdout0_1ck21 = 3.3 time = 220
.meas tran vdout0_1ck21 FIND v(dout0_1) AT=220.05n

* CHECK dout0_2 Vdout0_2ck21 = 3.3 time = 220
.meas tran vdout0_2ck21 FIND v(dout0_2) AT=220.05n

* CHECK dout0_3 Vdout0_3ck21 = 3.3 time = 220
.meas tran vdout0_3ck21 FIND v(dout0_3) AT=220.05n

* CHECK dout0_4 Vdout0_4ck21 = 3.3 time = 220
.meas tran vdout0_4ck21 FIND v(dout0_4) AT=220.05n

* CHECK dout0_5 Vdout0_5ck21 = 0 time = 220
.meas tran vdout0_5ck21 FIND v(dout0_5) AT=220.05n

* CHECK dout0_6 Vdout0_6ck21 = 3.3 time = 220
.meas tran vdout0_6ck21 FIND v(dout0_6) AT=220.05n

* CHECK dout0_7 Vdout0_7ck21 = 3.3 time = 220
.meas tran vdout0_7ck21 FIND v(dout0_7) AT=220.05n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 250
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=250.05n

* CHECK dout0_1 Vdout0_1ck24 = 3.3 time = 250
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=250.05n

* CHECK dout0_2 Vdout0_2ck24 = 3.3 time = 250
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=250.05n

* CHECK dout0_3 Vdout0_3ck24 = 3.3 time = 250
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=250.05n

* CHECK dout0_4 Vdout0_4ck24 = 3.3 time = 250
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=250.05n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 250
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=250.05n

* CHECK dout0_6 Vdout0_6ck24 = 3.3 time = 250
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=250.05n

* CHECK dout0_7 Vdout0_7ck24 = 3.3 time = 250
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=250.05n

* CHECK dout0_0 Vdout0_0ck25 = 0 time = 260
.meas tran vdout0_0ck25 FIND v(dout0_0) AT=260.05n

* CHECK dout0_1 Vdout0_1ck25 = 0 time = 260
.meas tran vdout0_1ck25 FIND v(dout0_1) AT=260.05n

* CHECK dout0_2 Vdout0_2ck25 = 0 time = 260
.meas tran vdout0_2ck25 FIND v(dout0_2) AT=260.05n

* CHECK dout0_3 Vdout0_3ck25 = 0 time = 260
.meas tran vdout0_3ck25 FIND v(dout0_3) AT=260.05n

* CHECK dout0_4 Vdout0_4ck25 = 3.3 time = 260
.meas tran vdout0_4ck25 FIND v(dout0_4) AT=260.05n

* CHECK dout0_5 Vdout0_5ck25 = 3.3 time = 260
.meas tran vdout0_5ck25 FIND v(dout0_5) AT=260.05n

* CHECK dout0_6 Vdout0_6ck25 = 3.3 time = 260
.meas tran vdout0_6ck25 FIND v(dout0_6) AT=260.05n

* CHECK dout0_7 Vdout0_7ck25 = 3.3 time = 260
.meas tran vdout0_7ck25 FIND v(dout0_7) AT=260.05n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 3.3 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 3.3 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 3.3 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 3.3 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 3.3 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 3.3 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_0 Vdout0_0ck31 = 0 time = 320
.meas tran vdout0_0ck31 FIND v(dout0_0) AT=320.05n

* CHECK dout0_1 Vdout0_1ck31 = 3.3 time = 320
.meas tran vdout0_1ck31 FIND v(dout0_1) AT=320.05n

* CHECK dout0_2 Vdout0_2ck31 = 0 time = 320
.meas tran vdout0_2ck31 FIND v(dout0_2) AT=320.05n

* CHECK dout0_3 Vdout0_3ck31 = 0 time = 320
.meas tran vdout0_3ck31 FIND v(dout0_3) AT=320.05n

* CHECK dout0_4 Vdout0_4ck31 = 0 time = 320
.meas tran vdout0_4ck31 FIND v(dout0_4) AT=320.05n

* CHECK dout0_5 Vdout0_5ck31 = 3.3 time = 320
.meas tran vdout0_5ck31 FIND v(dout0_5) AT=320.05n

* CHECK dout0_6 Vdout0_6ck31 = 0 time = 320
.meas tran vdout0_6ck31 FIND v(dout0_6) AT=320.05n

* CHECK dout0_7 Vdout0_7ck31 = 0 time = 320
.meas tran vdout0_7ck31 FIND v(dout0_7) AT=320.05n

* CHECK dout0_0 Vdout0_0ck33 = 0 time = 340
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=340.05n

* CHECK dout0_1 Vdout0_1ck33 = 3.3 time = 340
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=340.05n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 340
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=340.05n

* CHECK dout0_3 Vdout0_3ck33 = 0 time = 340
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=340.05n

* CHECK dout0_4 Vdout0_4ck33 = 0 time = 340
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=340.05n

* CHECK dout0_5 Vdout0_5ck33 = 3.3 time = 340
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=340.05n

* CHECK dout0_6 Vdout0_6ck33 = 0 time = 340
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=340.05n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 340
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=340.05n

* CHECK dout0_0 Vdout0_0ck34 = 3.3 time = 350
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=350.05n

* CHECK dout0_1 Vdout0_1ck34 = 3.3 time = 350
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=350.05n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 350
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=350.05n

* CHECK dout0_3 Vdout0_3ck34 = 0 time = 350
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=350.05n

* CHECK dout0_4 Vdout0_4ck34 = 3.3 time = 350
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=350.05n

* CHECK dout0_5 Vdout0_5ck34 = 0 time = 350
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=350.05n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 350
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=350.05n

* CHECK dout0_7 Vdout0_7ck34 = 3.3 time = 350
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=350.05n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 360
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=360.05n

* CHECK dout0_1 Vdout0_1ck35 = 3.3 time = 360
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=360.05n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 360
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=360.05n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 360
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=360.05n

* CHECK dout0_4 Vdout0_4ck35 = 0 time = 360
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=360.05n

* CHECK dout0_5 Vdout0_5ck35 = 3.3 time = 360
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=360.05n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 360
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=360.05n

* CHECK dout0_7 Vdout0_7ck35 = 0 time = 360
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=360.05n

* CHECK dout0_0 Vdout0_0ck36 = 3.3 time = 370
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=370.05n

* CHECK dout0_1 Vdout0_1ck36 = 3.3 time = 370
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=370.05n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 370
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=370.05n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 370
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=370.05n

* CHECK dout0_4 Vdout0_4ck36 = 3.3 time = 370
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=370.05n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 370
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=370.05n

* CHECK dout0_6 Vdout0_6ck36 = 0 time = 370
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=370.05n

* CHECK dout0_7 Vdout0_7ck36 = 3.3 time = 370
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=370.05n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 410
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=410.05n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 410
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=410.05n

* CHECK dout0_2 Vdout0_2ck40 = 3.3 time = 410
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=410.05n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 410
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=410.05n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 410
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=410.05n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 410
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=410.05n

* CHECK dout0_6 Vdout0_6ck40 = 0 time = 410
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=410.05n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 410
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=410.05n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 420
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=420.05n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 420
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=420.05n

* CHECK dout0_2 Vdout0_2ck41 = 3.3 time = 420
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=420.05n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 420
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=420.05n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 420
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=420.05n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 420
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=420.05n

* CHECK dout0_6 Vdout0_6ck41 = 0 time = 420
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=420.05n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 420
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=420.05n

* CHECK dout0_0 Vdout0_0ck45 = 0 time = 460
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=460.05n

* CHECK dout0_1 Vdout0_1ck45 = 0 time = 460
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=460.05n

* CHECK dout0_2 Vdout0_2ck45 = 3.3 time = 460
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=460.05n

* CHECK dout0_3 Vdout0_3ck45 = 3.3 time = 460
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=460.05n

* CHECK dout0_4 Vdout0_4ck45 = 0 time = 460
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=460.05n

* CHECK dout0_5 Vdout0_5ck45 = 0 time = 460
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=460.05n

* CHECK dout0_6 Vdout0_6ck45 = 3.3 time = 460
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=460.05n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 460
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=460.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 3.3 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 3.3 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 3.3 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 0 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 3.3 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 0 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_0 Vdout0_0ck48 = 0 time = 490
.meas tran vdout0_0ck48 FIND v(dout0_0) AT=490.05n

* CHECK dout0_1 Vdout0_1ck48 = 3.3 time = 490
.meas tran vdout0_1ck48 FIND v(dout0_1) AT=490.05n

* CHECK dout0_2 Vdout0_2ck48 = 0 time = 490
.meas tran vdout0_2ck48 FIND v(dout0_2) AT=490.05n

* CHECK dout0_3 Vdout0_3ck48 = 0 time = 490
.meas tran vdout0_3ck48 FIND v(dout0_3) AT=490.05n

* CHECK dout0_4 Vdout0_4ck48 = 0 time = 490
.meas tran vdout0_4ck48 FIND v(dout0_4) AT=490.05n

* CHECK dout0_5 Vdout0_5ck48 = 0 time = 490
.meas tran vdout0_5ck48 FIND v(dout0_5) AT=490.05n

* CHECK dout0_6 Vdout0_6ck48 = 3.3 time = 490
.meas tran vdout0_6ck48 FIND v(dout0_6) AT=490.05n

* CHECK dout0_7 Vdout0_7ck48 = 3.3 time = 490
.meas tran vdout0_7ck48 FIND v(dout0_7) AT=490.05n

* CHECK dout0_0 Vdout0_0ck49 = 0 time = 500
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=500.05n

* CHECK dout0_1 Vdout0_1ck49 = 3.3 time = 500
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=500.05n

* CHECK dout0_2 Vdout0_2ck49 = 0 time = 500
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=500.05n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 500
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=500.05n

* CHECK dout0_4 Vdout0_4ck49 = 0 time = 500
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=500.05n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 500
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=500.05n

* CHECK dout0_6 Vdout0_6ck49 = 3.3 time = 500
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=500.05n

* CHECK dout0_7 Vdout0_7ck49 = 3.3 time = 500
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=500.05n

* CHECK dout0_0 Vdout0_0ck50 = 0 time = 510
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=510.05n

* CHECK dout0_1 Vdout0_1ck50 = 3.3 time = 510
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=510.05n

* CHECK dout0_2 Vdout0_2ck50 = 3.3 time = 510
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=510.05n

* CHECK dout0_3 Vdout0_3ck50 = 3.3 time = 510
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=510.05n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 510
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=510.05n

* CHECK dout0_5 Vdout0_5ck50 = 0 time = 510
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=510.05n

* CHECK dout0_6 Vdout0_6ck50 = 3.3 time = 510
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=510.05n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 510
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=510.05n

* CHECK dout0_0 Vdout0_0ck53 = 0 time = 540
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=540.05n

* CHECK dout0_1 Vdout0_1ck53 = 3.3 time = 540
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=540.05n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 540
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=540.05n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 540
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=540.05n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 540
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=540.05n

* CHECK dout0_5 Vdout0_5ck53 = 0 time = 540
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=540.05n

* CHECK dout0_6 Vdout0_6ck53 = 3.3 time = 540
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=540.05n

* CHECK dout0_7 Vdout0_7ck53 = 3.3 time = 540
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=540.05n

* CHECK dout0_0 Vdout0_0ck55 = 0 time = 560
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=560.05n

* CHECK dout0_1 Vdout0_1ck55 = 0 time = 560
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=560.05n

* CHECK dout0_2 Vdout0_2ck55 = 3.3 time = 560
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=560.05n

* CHECK dout0_3 Vdout0_3ck55 = 0 time = 560
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=560.05n

* CHECK dout0_4 Vdout0_4ck55 = 0 time = 560
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=560.05n

* CHECK dout0_5 Vdout0_5ck55 = 3.3 time = 560
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=560.05n

* CHECK dout0_6 Vdout0_6ck55 = 3.3 time = 560
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=560.05n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 560
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=560.05n

* CHECK dout0_0 Vdout0_0ck57 = 0 time = 580
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=580.05n

* CHECK dout0_1 Vdout0_1ck57 = 3.3 time = 580
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=580.05n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 580
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=580.05n

* CHECK dout0_3 Vdout0_3ck57 = 0 time = 580
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=580.05n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 580
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=580.05n

* CHECK dout0_5 Vdout0_5ck57 = 0 time = 580
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=580.05n

* CHECK dout0_6 Vdout0_6ck57 = 3.3 time = 580
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=580.05n

* CHECK dout0_7 Vdout0_7ck57 = 3.3 time = 580
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=580.05n

* CHECK dout0_0 Vdout0_0ck58 = 0 time = 590
.meas tran vdout0_0ck58 FIND v(dout0_0) AT=590.05n

* CHECK dout0_1 Vdout0_1ck58 = 3.3 time = 590
.meas tran vdout0_1ck58 FIND v(dout0_1) AT=590.05n

* CHECK dout0_2 Vdout0_2ck58 = 0 time = 590
.meas tran vdout0_2ck58 FIND v(dout0_2) AT=590.05n

* CHECK dout0_3 Vdout0_3ck58 = 0 time = 590
.meas tran vdout0_3ck58 FIND v(dout0_3) AT=590.05n

* CHECK dout0_4 Vdout0_4ck58 = 0 time = 590
.meas tran vdout0_4ck58 FIND v(dout0_4) AT=590.05n

* CHECK dout0_5 Vdout0_5ck58 = 0 time = 590
.meas tran vdout0_5ck58 FIND v(dout0_5) AT=590.05n

* CHECK dout0_6 Vdout0_6ck58 = 3.3 time = 590
.meas tran vdout0_6ck58 FIND v(dout0_6) AT=590.05n

* CHECK dout0_7 Vdout0_7ck58 = 3.3 time = 590
.meas tran vdout0_7ck58 FIND v(dout0_7) AT=590.05n

* CHECK dout0_0 Vdout0_0ck60 = 0 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 3.3 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 3.3 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 3.3 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 0 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_0 Vdout0_0ck63 = 0 time = 640
.meas tran vdout0_0ck63 FIND v(dout0_0) AT=640.05n

* CHECK dout0_1 Vdout0_1ck63 = 3.3 time = 640
.meas tran vdout0_1ck63 FIND v(dout0_1) AT=640.05n

* CHECK dout0_2 Vdout0_2ck63 = 0 time = 640
.meas tran vdout0_2ck63 FIND v(dout0_2) AT=640.05n

* CHECK dout0_3 Vdout0_3ck63 = 0 time = 640
.meas tran vdout0_3ck63 FIND v(dout0_3) AT=640.05n

* CHECK dout0_4 Vdout0_4ck63 = 0 time = 640
.meas tran vdout0_4ck63 FIND v(dout0_4) AT=640.05n

* CHECK dout0_5 Vdout0_5ck63 = 0 time = 640
.meas tran vdout0_5ck63 FIND v(dout0_5) AT=640.05n

* CHECK dout0_6 Vdout0_6ck63 = 3.3 time = 640
.meas tran vdout0_6ck63 FIND v(dout0_6) AT=640.05n

* CHECK dout0_7 Vdout0_7ck63 = 3.3 time = 640
.meas tran vdout0_7ck63 FIND v(dout0_7) AT=640.05n

* CHECK dout0_0 Vdout0_0ck64 = 0 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 3.3 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 0 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 0 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 3.3 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 3.3 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 670
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=670.05n

* CHECK dout0_1 Vdout0_1ck66 = 0 time = 670
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=670.05n

* CHECK dout0_2 Vdout0_2ck66 = 3.3 time = 670
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=670.05n

* CHECK dout0_3 Vdout0_3ck66 = 3.3 time = 670
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=670.05n

* CHECK dout0_4 Vdout0_4ck66 = 3.3 time = 670
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=670.05n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 670
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=670.05n

* CHECK dout0_6 Vdout0_6ck66 = 3.3 time = 670
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=670.05n

* CHECK dout0_7 Vdout0_7ck66 = 3.3 time = 670
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=670.05n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 680
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=680.05n

* CHECK dout0_1 Vdout0_1ck67 = 0 time = 680
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=680.05n

* CHECK dout0_2 Vdout0_2ck67 = 3.3 time = 680
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=680.05n

* CHECK dout0_3 Vdout0_3ck67 = 3.3 time = 680
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=680.05n

* CHECK dout0_4 Vdout0_4ck67 = 3.3 time = 680
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=680.05n

* CHECK dout0_5 Vdout0_5ck67 = 0 time = 680
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=680.05n

* CHECK dout0_6 Vdout0_6ck67 = 3.3 time = 680
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=680.05n

* CHECK dout0_7 Vdout0_7ck67 = 3.3 time = 680
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=680.05n

* CHECK dout0_0 Vdout0_0ck69 = 0 time = 700
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=700.05n

* CHECK dout0_1 Vdout0_1ck69 = 0 time = 700
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=700.05n

* CHECK dout0_2 Vdout0_2ck69 = 3.3 time = 700
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=700.05n

* CHECK dout0_3 Vdout0_3ck69 = 0 time = 700
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=700.05n

* CHECK dout0_4 Vdout0_4ck69 = 0 time = 700
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=700.05n

* CHECK dout0_5 Vdout0_5ck69 = 3.3 time = 700
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=700.05n

* CHECK dout0_6 Vdout0_6ck69 = 3.3 time = 700
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=700.05n

* CHECK dout0_7 Vdout0_7ck69 = 0 time = 700
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=700.05n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 0 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 3.3 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 3.3 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 3.3 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 0 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 3.3 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 3.3 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 750
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=750.05n

* CHECK dout0_1 Vdout0_1ck74 = 0 time = 750
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=750.05n

* CHECK dout0_2 Vdout0_2ck74 = 3.3 time = 750
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=750.05n

* CHECK dout0_3 Vdout0_3ck74 = 3.3 time = 750
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=750.05n

* CHECK dout0_4 Vdout0_4ck74 = 3.3 time = 750
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=750.05n

* CHECK dout0_5 Vdout0_5ck74 = 0 time = 750
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=750.05n

* CHECK dout0_6 Vdout0_6ck74 = 3.3 time = 750
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=750.05n

* CHECK dout0_7 Vdout0_7ck74 = 3.3 time = 750
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=750.05n

* CHECK dout0_0 Vdout0_0ck76 = 0 time = 770
.meas tran vdout0_0ck76 FIND v(dout0_0) AT=770.05n

* CHECK dout0_1 Vdout0_1ck76 = 0 time = 770
.meas tran vdout0_1ck76 FIND v(dout0_1) AT=770.05n

* CHECK dout0_2 Vdout0_2ck76 = 3.3 time = 770
.meas tran vdout0_2ck76 FIND v(dout0_2) AT=770.05n

* CHECK dout0_3 Vdout0_3ck76 = 3.3 time = 770
.meas tran vdout0_3ck76 FIND v(dout0_3) AT=770.05n

* CHECK dout0_4 Vdout0_4ck76 = 3.3 time = 770
.meas tran vdout0_4ck76 FIND v(dout0_4) AT=770.05n

* CHECK dout0_5 Vdout0_5ck76 = 0 time = 770
.meas tran vdout0_5ck76 FIND v(dout0_5) AT=770.05n

* CHECK dout0_6 Vdout0_6ck76 = 3.3 time = 770
.meas tran vdout0_6ck76 FIND v(dout0_6) AT=770.05n

* CHECK dout0_7 Vdout0_7ck76 = 3.3 time = 770
.meas tran vdout0_7ck76 FIND v(dout0_7) AT=770.05n

* CHECK dout0_0 Vdout0_0ck78 = 0 time = 790
.meas tran vdout0_0ck78 FIND v(dout0_0) AT=790.05n

* CHECK dout0_1 Vdout0_1ck78 = 0 time = 790
.meas tran vdout0_1ck78 FIND v(dout0_1) AT=790.05n

* CHECK dout0_2 Vdout0_2ck78 = 3.3 time = 790
.meas tran vdout0_2ck78 FIND v(dout0_2) AT=790.05n

* CHECK dout0_3 Vdout0_3ck78 = 3.3 time = 790
.meas tran vdout0_3ck78 FIND v(dout0_3) AT=790.05n

* CHECK dout0_4 Vdout0_4ck78 = 3.3 time = 790
.meas tran vdout0_4ck78 FIND v(dout0_4) AT=790.05n

* CHECK dout0_5 Vdout0_5ck78 = 0 time = 790
.meas tran vdout0_5ck78 FIND v(dout0_5) AT=790.05n

* CHECK dout0_6 Vdout0_6ck78 = 3.3 time = 790
.meas tran vdout0_6ck78 FIND v(dout0_6) AT=790.05n

* CHECK dout0_7 Vdout0_7ck78 = 3.3 time = 790
.meas tran vdout0_7ck78 FIND v(dout0_7) AT=790.05n

* CHECK dout0_0 Vdout0_0ck79 = 3.3 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 3.3 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 3.3 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 3.3 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 3.3 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_0 Vdout0_0ck80 = 3.3 time = 810
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=810.05n

* CHECK dout0_1 Vdout0_1ck80 = 3.3 time = 810
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=810.05n

* CHECK dout0_2 Vdout0_2ck80 = 3.3 time = 810
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=810.05n

* CHECK dout0_3 Vdout0_3ck80 = 0 time = 810
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=810.05n

* CHECK dout0_4 Vdout0_4ck80 = 0 time = 810
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=810.05n

* CHECK dout0_5 Vdout0_5ck80 = 3.3 time = 810
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=810.05n

* CHECK dout0_6 Vdout0_6ck80 = 0 time = 810
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=810.05n

* CHECK dout0_7 Vdout0_7ck80 = 3.3 time = 810
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=810.05n

* CHECK dout0_0 Vdout0_0ck82 = 3.3 time = 830
.meas tran vdout0_0ck82 FIND v(dout0_0) AT=830.05n

* CHECK dout0_1 Vdout0_1ck82 = 3.3 time = 830
.meas tran vdout0_1ck82 FIND v(dout0_1) AT=830.05n

* CHECK dout0_2 Vdout0_2ck82 = 3.3 time = 830
.meas tran vdout0_2ck82 FIND v(dout0_2) AT=830.05n

* CHECK dout0_3 Vdout0_3ck82 = 0 time = 830
.meas tran vdout0_3ck82 FIND v(dout0_3) AT=830.05n

* CHECK dout0_4 Vdout0_4ck82 = 0 time = 830
.meas tran vdout0_4ck82 FIND v(dout0_4) AT=830.05n

* CHECK dout0_5 Vdout0_5ck82 = 3.3 time = 830
.meas tran vdout0_5ck82 FIND v(dout0_5) AT=830.05n

* CHECK dout0_6 Vdout0_6ck82 = 0 time = 830
.meas tran vdout0_6ck82 FIND v(dout0_6) AT=830.05n

* CHECK dout0_7 Vdout0_7ck82 = 3.3 time = 830
.meas tran vdout0_7ck82 FIND v(dout0_7) AT=830.05n

* CHECK dout0_0 Vdout0_0ck83 = 3.3 time = 840
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=840.05n

* CHECK dout0_1 Vdout0_1ck83 = 3.3 time = 840
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=840.05n

* CHECK dout0_2 Vdout0_2ck83 = 3.3 time = 840
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=840.05n

* CHECK dout0_3 Vdout0_3ck83 = 3.3 time = 840
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=840.05n

* CHECK dout0_4 Vdout0_4ck83 = 3.3 time = 840
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=840.05n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 840
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=840.05n

* CHECK dout0_6 Vdout0_6ck83 = 0 time = 840
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=840.05n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 840
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=840.05n

* CHECK dout0_0 Vdout0_0ck85 = 3.3 time = 860
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=860.05n

* CHECK dout0_1 Vdout0_1ck85 = 3.3 time = 860
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=860.05n

* CHECK dout0_2 Vdout0_2ck85 = 3.3 time = 860
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=860.05n

* CHECK dout0_3 Vdout0_3ck85 = 0 time = 860
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=860.05n

* CHECK dout0_4 Vdout0_4ck85 = 0 time = 860
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=860.05n

* CHECK dout0_5 Vdout0_5ck85 = 3.3 time = 860
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=860.05n

* CHECK dout0_6 Vdout0_6ck85 = 0 time = 860
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=860.05n

* CHECK dout0_7 Vdout0_7ck85 = 3.3 time = 860
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=860.05n

* CHECK dout0_0 Vdout0_0ck86 = 3.3 time = 870
.meas tran vdout0_0ck86 FIND v(dout0_0) AT=870.05n

* CHECK dout0_1 Vdout0_1ck86 = 3.3 time = 870
.meas tran vdout0_1ck86 FIND v(dout0_1) AT=870.05n

* CHECK dout0_2 Vdout0_2ck86 = 3.3 time = 870
.meas tran vdout0_2ck86 FIND v(dout0_2) AT=870.05n

* CHECK dout0_3 Vdout0_3ck86 = 0 time = 870
.meas tran vdout0_3ck86 FIND v(dout0_3) AT=870.05n

* CHECK dout0_4 Vdout0_4ck86 = 0 time = 870
.meas tran vdout0_4ck86 FIND v(dout0_4) AT=870.05n

* CHECK dout0_5 Vdout0_5ck86 = 3.3 time = 870
.meas tran vdout0_5ck86 FIND v(dout0_5) AT=870.05n

* CHECK dout0_6 Vdout0_6ck86 = 0 time = 870
.meas tran vdout0_6ck86 FIND v(dout0_6) AT=870.05n

* CHECK dout0_7 Vdout0_7ck86 = 3.3 time = 870
.meas tran vdout0_7ck86 FIND v(dout0_7) AT=870.05n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 900
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=900.05n

* CHECK dout0_1 Vdout0_1ck89 = 3.3 time = 900
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=900.05n

* CHECK dout0_2 Vdout0_2ck89 = 0 time = 900
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=900.05n

* CHECK dout0_3 Vdout0_3ck89 = 0 time = 900
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=900.05n

* CHECK dout0_4 Vdout0_4ck89 = 0 time = 900
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=900.05n

* CHECK dout0_5 Vdout0_5ck89 = 0 time = 900
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=900.05n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 900
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=900.05n

* CHECK dout0_7 Vdout0_7ck89 = 3.3 time = 900
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=900.05n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 910
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=910.05n

* CHECK dout0_1 Vdout0_1ck90 = 3.3 time = 910
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=910.05n

* CHECK dout0_2 Vdout0_2ck90 = 0 time = 910
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=910.05n

* CHECK dout0_3 Vdout0_3ck90 = 0 time = 910
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=910.05n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 910
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=910.05n

* CHECK dout0_5 Vdout0_5ck90 = 0 time = 910
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=910.05n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 910
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=910.05n

* CHECK dout0_7 Vdout0_7ck90 = 3.3 time = 910
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=910.05n

* CHECK dout0_0 Vdout0_0ck91 = 0 time = 920
.meas tran vdout0_0ck91 FIND v(dout0_0) AT=920.05n

* CHECK dout0_1 Vdout0_1ck91 = 3.3 time = 920
.meas tran vdout0_1ck91 FIND v(dout0_1) AT=920.05n

* CHECK dout0_2 Vdout0_2ck91 = 0 time = 920
.meas tran vdout0_2ck91 FIND v(dout0_2) AT=920.05n

* CHECK dout0_3 Vdout0_3ck91 = 0 time = 920
.meas tran vdout0_3ck91 FIND v(dout0_3) AT=920.05n

* CHECK dout0_4 Vdout0_4ck91 = 0 time = 920
.meas tran vdout0_4ck91 FIND v(dout0_4) AT=920.05n

* CHECK dout0_5 Vdout0_5ck91 = 0 time = 920
.meas tran vdout0_5ck91 FIND v(dout0_5) AT=920.05n

* CHECK dout0_6 Vdout0_6ck91 = 0 time = 920
.meas tran vdout0_6ck91 FIND v(dout0_6) AT=920.05n

* CHECK dout0_7 Vdout0_7ck91 = 3.3 time = 920
.meas tran vdout0_7ck91 FIND v(dout0_7) AT=920.05n

* CHECK dout0_0 Vdout0_0ck93 = 3.3 time = 940
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=940.05n

* CHECK dout0_1 Vdout0_1ck93 = 3.3 time = 940
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=940.05n

* CHECK dout0_2 Vdout0_2ck93 = 3.3 time = 940
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=940.05n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 940
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=940.05n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 940
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=940.05n

* CHECK dout0_5 Vdout0_5ck93 = 3.3 time = 940
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=940.05n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 940
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=940.05n

* CHECK dout0_7 Vdout0_7ck93 = 3.3 time = 940
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=940.05n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 950
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=950.05n

* CHECK dout0_1 Vdout0_1ck94 = 3.3 time = 950
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=950.05n

* CHECK dout0_2 Vdout0_2ck94 = 0 time = 950
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=950.05n

* CHECK dout0_3 Vdout0_3ck94 = 0 time = 950
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=950.05n

* CHECK dout0_4 Vdout0_4ck94 = 0 time = 950
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=950.05n

* CHECK dout0_5 Vdout0_5ck94 = 0 time = 950
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=950.05n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 950
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=950.05n

* CHECK dout0_7 Vdout0_7ck94 = 3.3 time = 950
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=950.05n

* CHECK dout0_0 Vdout0_0ck95 = 3.3 time = 960
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=960.05n

* CHECK dout0_1 Vdout0_1ck95 = 3.3 time = 960
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=960.05n

* CHECK dout0_2 Vdout0_2ck95 = 3.3 time = 960
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=960.05n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 960
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=960.05n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 960
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=960.05n

* CHECK dout0_5 Vdout0_5ck95 = 3.3 time = 960
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=960.05n

* CHECK dout0_6 Vdout0_6ck95 = 0 time = 960
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=960.05n

* CHECK dout0_7 Vdout0_7ck95 = 3.3 time = 960
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=960.05n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 3.3 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 3.3 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_0 Vdout0_0ck97 = 0 time = 980
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=980.05n

* CHECK dout0_1 Vdout0_1ck97 = 3.3 time = 980
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=980.05n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 980
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=980.05n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 980
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=980.05n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 980
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=980.05n

* CHECK dout0_5 Vdout0_5ck97 = 0 time = 980
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=980.05n

* CHECK dout0_6 Vdout0_6ck97 = 0 time = 980
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=980.05n

* CHECK dout0_7 Vdout0_7ck97 = 3.3 time = 980
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=980.05n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 1000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=1000.05n

* CHECK dout0_1 Vdout0_1ck99 = 3.3 time = 1000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=1000.05n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 1000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=1000.05n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 1000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=1000.05n

* CHECK dout0_4 Vdout0_4ck99 = 0 time = 1000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=1000.05n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 1000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=1000.05n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 1000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=1000.05n

* CHECK dout0_7 Vdout0_7ck99 = 3.3 time = 1000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=1000.05n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 3.3 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 0 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 0 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 3.3 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck103 = 3.3 time = 1040
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=1040.05n

* CHECK dout0_1 Vdout0_1ck103 = 3.3 time = 1040
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=1040.05n

* CHECK dout0_2 Vdout0_2ck103 = 3.3 time = 1040
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=1040.05n

* CHECK dout0_3 Vdout0_3ck103 = 0 time = 1040
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=1040.05n

* CHECK dout0_4 Vdout0_4ck103 = 0 time = 1040
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=1040.05n

* CHECK dout0_5 Vdout0_5ck103 = 3.3 time = 1040
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=1040.05n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 1040
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=1040.05n

* CHECK dout0_7 Vdout0_7ck103 = 3.3 time = 1040
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=1040.05n

* CHECK dout0_0 Vdout0_0ck108 = 3.3 time = 1090
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=1090.05n

* CHECK dout0_1 Vdout0_1ck108 = 3.3 time = 1090
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=1090.05n

* CHECK dout0_2 Vdout0_2ck108 = 3.3 time = 1090
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=1090.05n

* CHECK dout0_3 Vdout0_3ck108 = 3.3 time = 1090
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=1090.05n

* CHECK dout0_4 Vdout0_4ck108 = 3.3 time = 1090
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=1090.05n

* CHECK dout0_5 Vdout0_5ck108 = 0 time = 1090
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=1090.05n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 1090
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=1090.05n

* CHECK dout0_7 Vdout0_7ck108 = 0 time = 1090
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=1090.05n

* CHECK dout0_0 Vdout0_0ck110 = 3.3 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 3.3 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 3.3 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 3.3 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 3.3 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 0 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 1130
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=1130.05n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 1130
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=1130.05n

* CHECK dout0_2 Vdout0_2ck112 = 3.3 time = 1130
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=1130.05n

* CHECK dout0_3 Vdout0_3ck112 = 3.3 time = 1130
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=1130.05n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 1130
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=1130.05n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 1130
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=1130.05n

* CHECK dout0_6 Vdout0_6ck112 = 3.3 time = 1130
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=1130.05n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 1130
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=1130.05n

* CHECK dout0_0 Vdout0_0ck113 = 0 time = 1140
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=1140.05n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 1140
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=1140.05n

* CHECK dout0_2 Vdout0_2ck113 = 3.3 time = 1140
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=1140.05n

* CHECK dout0_3 Vdout0_3ck113 = 3.3 time = 1140
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=1140.05n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 1140
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=1140.05n

* CHECK dout0_5 Vdout0_5ck113 = 0 time = 1140
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=1140.05n

* CHECK dout0_6 Vdout0_6ck113 = 3.3 time = 1140
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=1140.05n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 1140
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=1140.05n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 1160
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=1160.05n

* CHECK dout0_1 Vdout0_1ck115 = 0 time = 1160
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=1160.05n

* CHECK dout0_2 Vdout0_2ck115 = 3.3 time = 1160
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=1160.05n

* CHECK dout0_3 Vdout0_3ck115 = 3.3 time = 1160
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=1160.05n

* CHECK dout0_4 Vdout0_4ck115 = 0 time = 1160
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=1160.05n

* CHECK dout0_5 Vdout0_5ck115 = 0 time = 1160
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=1160.05n

* CHECK dout0_6 Vdout0_6ck115 = 3.3 time = 1160
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=1160.05n

* CHECK dout0_7 Vdout0_7ck115 = 0 time = 1160
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=1160.05n

* CHECK dout0_0 Vdout0_0ck121 = 3.3 time = 1220
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=1220.05n

* CHECK dout0_1 Vdout0_1ck121 = 3.3 time = 1220
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=1220.05n

* CHECK dout0_2 Vdout0_2ck121 = 3.3 time = 1220
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=1220.05n

* CHECK dout0_3 Vdout0_3ck121 = 0 time = 1220
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=1220.05n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 1220
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=1220.05n

* CHECK dout0_5 Vdout0_5ck121 = 3.3 time = 1220
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=1220.05n

* CHECK dout0_6 Vdout0_6ck121 = 0 time = 1220
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=1220.05n

* CHECK dout0_7 Vdout0_7ck121 = 3.3 time = 1220
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=1220.05n

* CHECK dout0_0 Vdout0_0ck122 = 0 time = 1230
.meas tran vdout0_0ck122 FIND v(dout0_0) AT=1230.05n

* CHECK dout0_1 Vdout0_1ck122 = 3.3 time = 1230
.meas tran vdout0_1ck122 FIND v(dout0_1) AT=1230.05n

* CHECK dout0_2 Vdout0_2ck122 = 0 time = 1230
.meas tran vdout0_2ck122 FIND v(dout0_2) AT=1230.05n

* CHECK dout0_3 Vdout0_3ck122 = 0 time = 1230
.meas tran vdout0_3ck122 FIND v(dout0_3) AT=1230.05n

* CHECK dout0_4 Vdout0_4ck122 = 3.3 time = 1230
.meas tran vdout0_4ck122 FIND v(dout0_4) AT=1230.05n

* CHECK dout0_5 Vdout0_5ck122 = 3.3 time = 1230
.meas tran vdout0_5ck122 FIND v(dout0_5) AT=1230.05n

* CHECK dout0_6 Vdout0_6ck122 = 3.3 time = 1230
.meas tran vdout0_6ck122 FIND v(dout0_6) AT=1230.05n

* CHECK dout0_7 Vdout0_7ck122 = 3.3 time = 1230
.meas tran vdout0_7ck122 FIND v(dout0_7) AT=1230.05n

* CHECK dout0_0 Vdout0_0ck123 = 3.3 time = 1240
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=1240.05n

* CHECK dout0_1 Vdout0_1ck123 = 3.3 time = 1240
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=1240.05n

* CHECK dout0_2 Vdout0_2ck123 = 3.3 time = 1240
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=1240.05n

* CHECK dout0_3 Vdout0_3ck123 = 0 time = 1240
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=1240.05n

* CHECK dout0_4 Vdout0_4ck123 = 0 time = 1240
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=1240.05n

* CHECK dout0_5 Vdout0_5ck123 = 3.3 time = 1240
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=1240.05n

* CHECK dout0_6 Vdout0_6ck123 = 0 time = 1240
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=1240.05n

* CHECK dout0_7 Vdout0_7ck123 = 3.3 time = 1240
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=1240.05n

* CHECK dout0_0 Vdout0_0ck125 = 3.3 time = 1260
.meas tran vdout0_0ck125 FIND v(dout0_0) AT=1260.05n

* CHECK dout0_1 Vdout0_1ck125 = 3.3 time = 1260
.meas tran vdout0_1ck125 FIND v(dout0_1) AT=1260.05n

* CHECK dout0_2 Vdout0_2ck125 = 3.3 time = 1260
.meas tran vdout0_2ck125 FIND v(dout0_2) AT=1260.05n

* CHECK dout0_3 Vdout0_3ck125 = 0 time = 1260
.meas tran vdout0_3ck125 FIND v(dout0_3) AT=1260.05n

* CHECK dout0_4 Vdout0_4ck125 = 0 time = 1260
.meas tran vdout0_4ck125 FIND v(dout0_4) AT=1260.05n

* CHECK dout0_5 Vdout0_5ck125 = 3.3 time = 1260
.meas tran vdout0_5ck125 FIND v(dout0_5) AT=1260.05n

* CHECK dout0_6 Vdout0_6ck125 = 0 time = 1260
.meas tran vdout0_6ck125 FIND v(dout0_6) AT=1260.05n

* CHECK dout0_7 Vdout0_7ck125 = 3.3 time = 1260
.meas tran vdout0_7ck125 FIND v(dout0_7) AT=1260.05n

* CHECK dout0_0 Vdout0_0ck130 = 0 time = 1310
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=1310.05n

* CHECK dout0_1 Vdout0_1ck130 = 0 time = 1310
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=1310.05n

* CHECK dout0_2 Vdout0_2ck130 = 3.3 time = 1310
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=1310.05n

* CHECK dout0_3 Vdout0_3ck130 = 0 time = 1310
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=1310.05n

* CHECK dout0_4 Vdout0_4ck130 = 0 time = 1310
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=1310.05n

* CHECK dout0_5 Vdout0_5ck130 = 0 time = 1310
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=1310.05n

* CHECK dout0_6 Vdout0_6ck130 = 3.3 time = 1310
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=1310.05n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 1310
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=1310.05n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 1320
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=1320.05n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 1320
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=1320.05n

* CHECK dout0_2 Vdout0_2ck131 = 3.3 time = 1320
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=1320.05n

* CHECK dout0_3 Vdout0_3ck131 = 0 time = 1320
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=1320.05n

* CHECK dout0_4 Vdout0_4ck131 = 0 time = 1320
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=1320.05n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 1320
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=1320.05n

* CHECK dout0_6 Vdout0_6ck131 = 3.3 time = 1320
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=1320.05n

* CHECK dout0_7 Vdout0_7ck131 = 0 time = 1320
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=1320.05n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 1350
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=1350.05n

* CHECK dout0_1 Vdout0_1ck134 = 0 time = 1350
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=1350.05n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 1350
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=1350.05n

* CHECK dout0_3 Vdout0_3ck134 = 3.3 time = 1350
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=1350.05n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 1350
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=1350.05n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 1350
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=1350.05n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 1350
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=1350.05n

* CHECK dout0_7 Vdout0_7ck134 = 0 time = 1350
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=1350.05n

* CHECK dout0_0 Vdout0_0ck135 = 0 time = 1360
.meas tran vdout0_0ck135 FIND v(dout0_0) AT=1360.05n

* CHECK dout0_1 Vdout0_1ck135 = 0 time = 1360
.meas tran vdout0_1ck135 FIND v(dout0_1) AT=1360.05n

* CHECK dout0_2 Vdout0_2ck135 = 0 time = 1360
.meas tran vdout0_2ck135 FIND v(dout0_2) AT=1360.05n

* CHECK dout0_3 Vdout0_3ck135 = 3.3 time = 1360
.meas tran vdout0_3ck135 FIND v(dout0_3) AT=1360.05n

* CHECK dout0_4 Vdout0_4ck135 = 0 time = 1360
.meas tran vdout0_4ck135 FIND v(dout0_4) AT=1360.05n

* CHECK dout0_5 Vdout0_5ck135 = 0 time = 1360
.meas tran vdout0_5ck135 FIND v(dout0_5) AT=1360.05n

* CHECK dout0_6 Vdout0_6ck135 = 0 time = 1360
.meas tran vdout0_6ck135 FIND v(dout0_6) AT=1360.05n

* CHECK dout0_7 Vdout0_7ck135 = 0 time = 1360
.meas tran vdout0_7ck135 FIND v(dout0_7) AT=1360.05n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 3.3 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 0 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 0 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck140 = 0 time = 1410
.meas tran vdout0_0ck140 FIND v(dout0_0) AT=1410.05n

* CHECK dout0_1 Vdout0_1ck140 = 0 time = 1410
.meas tran vdout0_1ck140 FIND v(dout0_1) AT=1410.05n

* CHECK dout0_2 Vdout0_2ck140 = 0 time = 1410
.meas tran vdout0_2ck140 FIND v(dout0_2) AT=1410.05n

* CHECK dout0_3 Vdout0_3ck140 = 3.3 time = 1410
.meas tran vdout0_3ck140 FIND v(dout0_3) AT=1410.05n

* CHECK dout0_4 Vdout0_4ck140 = 0 time = 1410
.meas tran vdout0_4ck140 FIND v(dout0_4) AT=1410.05n

* CHECK dout0_5 Vdout0_5ck140 = 0 time = 1410
.meas tran vdout0_5ck140 FIND v(dout0_5) AT=1410.05n

* CHECK dout0_6 Vdout0_6ck140 = 0 time = 1410
.meas tran vdout0_6ck140 FIND v(dout0_6) AT=1410.05n

* CHECK dout0_7 Vdout0_7ck140 = 0 time = 1410
.meas tran vdout0_7ck140 FIND v(dout0_7) AT=1410.05n

* CHECK dout0_0 Vdout0_0ck141 = 0 time = 1420
.meas tran vdout0_0ck141 FIND v(dout0_0) AT=1420.05n

* CHECK dout0_1 Vdout0_1ck141 = 0 time = 1420
.meas tran vdout0_1ck141 FIND v(dout0_1) AT=1420.05n

* CHECK dout0_2 Vdout0_2ck141 = 0 time = 1420
.meas tran vdout0_2ck141 FIND v(dout0_2) AT=1420.05n

* CHECK dout0_3 Vdout0_3ck141 = 3.3 time = 1420
.meas tran vdout0_3ck141 FIND v(dout0_3) AT=1420.05n

* CHECK dout0_4 Vdout0_4ck141 = 0 time = 1420
.meas tran vdout0_4ck141 FIND v(dout0_4) AT=1420.05n

* CHECK dout0_5 Vdout0_5ck141 = 0 time = 1420
.meas tran vdout0_5ck141 FIND v(dout0_5) AT=1420.05n

* CHECK dout0_6 Vdout0_6ck141 = 0 time = 1420
.meas tran vdout0_6ck141 FIND v(dout0_6) AT=1420.05n

* CHECK dout0_7 Vdout0_7ck141 = 0 time = 1420
.meas tran vdout0_7ck141 FIND v(dout0_7) AT=1420.05n

* CHECK dout0_0 Vdout0_0ck146 = 3.3 time = 1470
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=1470.05n

* CHECK dout0_1 Vdout0_1ck146 = 3.3 time = 1470
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=1470.05n

* CHECK dout0_2 Vdout0_2ck146 = 3.3 time = 1470
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=1470.05n

* CHECK dout0_3 Vdout0_3ck146 = 3.3 time = 1470
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=1470.05n

* CHECK dout0_4 Vdout0_4ck146 = 3.3 time = 1470
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=1470.05n

* CHECK dout0_5 Vdout0_5ck146 = 3.3 time = 1470
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=1470.05n

* CHECK dout0_6 Vdout0_6ck146 = 0 time = 1470
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=1470.05n

* CHECK dout0_7 Vdout0_7ck146 = 3.3 time = 1470
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=1470.05n

* CHECK dout0_0 Vdout0_0ck147 = 3.3 time = 1480
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=1480.05n

* CHECK dout0_1 Vdout0_1ck147 = 3.3 time = 1480
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=1480.05n

* CHECK dout0_2 Vdout0_2ck147 = 3.3 time = 1480
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=1480.05n

* CHECK dout0_3 Vdout0_3ck147 = 3.3 time = 1480
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=1480.05n

* CHECK dout0_4 Vdout0_4ck147 = 3.3 time = 1480
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=1480.05n

* CHECK dout0_5 Vdout0_5ck147 = 3.3 time = 1480
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=1480.05n

* CHECK dout0_6 Vdout0_6ck147 = 0 time = 1480
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=1480.05n

* CHECK dout0_7 Vdout0_7ck147 = 3.3 time = 1480
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=1480.05n

* CHECK dout0_0 Vdout0_0ck148 = 3.3 time = 1490
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=1490.05n

* CHECK dout0_1 Vdout0_1ck148 = 3.3 time = 1490
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=1490.05n

* CHECK dout0_2 Vdout0_2ck148 = 3.3 time = 1490
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=1490.05n

* CHECK dout0_3 Vdout0_3ck148 = 3.3 time = 1490
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=1490.05n

* CHECK dout0_4 Vdout0_4ck148 = 3.3 time = 1490
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=1490.05n

* CHECK dout0_5 Vdout0_5ck148 = 3.3 time = 1490
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=1490.05n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 1490
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=1490.05n

* CHECK dout0_7 Vdout0_7ck148 = 3.3 time = 1490
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=1490.05n

* CHECK dout0_0 Vdout0_0ck149 = 3.3 time = 1500
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=1500.05n

* CHECK dout0_1 Vdout0_1ck149 = 3.3 time = 1500
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=1500.05n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 1500
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=1500.05n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 1500
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=1500.05n

* CHECK dout0_4 Vdout0_4ck149 = 3.3 time = 1500
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=1500.05n

* CHECK dout0_5 Vdout0_5ck149 = 3.3 time = 1500
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=1500.05n

* CHECK dout0_6 Vdout0_6ck149 = 3.3 time = 1500
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=1500.05n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 1500
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=1500.05n

* CHECK dout0_0 Vdout0_0ck151 = 3.3 time = 1520
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=1520.05n

* CHECK dout0_1 Vdout0_1ck151 = 3.3 time = 1520
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=1520.05n

* CHECK dout0_2 Vdout0_2ck151 = 3.3 time = 1520
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=1520.05n

* CHECK dout0_3 Vdout0_3ck151 = 3.3 time = 1520
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=1520.05n

* CHECK dout0_4 Vdout0_4ck151 = 3.3 time = 1520
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=1520.05n

* CHECK dout0_5 Vdout0_5ck151 = 3.3 time = 1520
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=1520.05n

* CHECK dout0_6 Vdout0_6ck151 = 0 time = 1520
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=1520.05n

* CHECK dout0_7 Vdout0_7ck151 = 3.3 time = 1520
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=1520.05n

* CHECK dout0_0 Vdout0_0ck156 = 3.3 time = 1570
.meas tran vdout0_0ck156 FIND v(dout0_0) AT=1570.05n

* CHECK dout0_1 Vdout0_1ck156 = 3.3 time = 1570
.meas tran vdout0_1ck156 FIND v(dout0_1) AT=1570.05n

* CHECK dout0_2 Vdout0_2ck156 = 3.3 time = 1570
.meas tran vdout0_2ck156 FIND v(dout0_2) AT=1570.05n

* CHECK dout0_3 Vdout0_3ck156 = 3.3 time = 1570
.meas tran vdout0_3ck156 FIND v(dout0_3) AT=1570.05n

* CHECK dout0_4 Vdout0_4ck156 = 3.3 time = 1570
.meas tran vdout0_4ck156 FIND v(dout0_4) AT=1570.05n

* CHECK dout0_5 Vdout0_5ck156 = 3.3 time = 1570
.meas tran vdout0_5ck156 FIND v(dout0_5) AT=1570.05n

* CHECK dout0_6 Vdout0_6ck156 = 0 time = 1570
.meas tran vdout0_6ck156 FIND v(dout0_6) AT=1570.05n

* CHECK dout0_7 Vdout0_7ck156 = 0 time = 1570
.meas tran vdout0_7ck156 FIND v(dout0_7) AT=1570.05n

* CHECK dout0_0 Vdout0_0ck158 = 0 time = 1590
.meas tran vdout0_0ck158 FIND v(dout0_0) AT=1590.05n

* CHECK dout0_1 Vdout0_1ck158 = 0 time = 1590
.meas tran vdout0_1ck158 FIND v(dout0_1) AT=1590.05n

* CHECK dout0_2 Vdout0_2ck158 = 3.3 time = 1590
.meas tran vdout0_2ck158 FIND v(dout0_2) AT=1590.05n

* CHECK dout0_3 Vdout0_3ck158 = 0 time = 1590
.meas tran vdout0_3ck158 FIND v(dout0_3) AT=1590.05n

* CHECK dout0_4 Vdout0_4ck158 = 0 time = 1590
.meas tran vdout0_4ck158 FIND v(dout0_4) AT=1590.05n

* CHECK dout0_5 Vdout0_5ck158 = 3.3 time = 1590
.meas tran vdout0_5ck158 FIND v(dout0_5) AT=1590.05n

* CHECK dout0_6 Vdout0_6ck158 = 3.3 time = 1590
.meas tran vdout0_6ck158 FIND v(dout0_6) AT=1590.05n

* CHECK dout0_7 Vdout0_7ck158 = 0 time = 1590
.meas tran vdout0_7ck158 FIND v(dout0_7) AT=1590.05n

* CHECK dout0_0 Vdout0_0ck159 = 0 time = 1600
.meas tran vdout0_0ck159 FIND v(dout0_0) AT=1600.05n

* CHECK dout0_1 Vdout0_1ck159 = 0 time = 1600
.meas tran vdout0_1ck159 FIND v(dout0_1) AT=1600.05n

* CHECK dout0_2 Vdout0_2ck159 = 3.3 time = 1600
.meas tran vdout0_2ck159 FIND v(dout0_2) AT=1600.05n

* CHECK dout0_3 Vdout0_3ck159 = 0 time = 1600
.meas tran vdout0_3ck159 FIND v(dout0_3) AT=1600.05n

* CHECK dout0_4 Vdout0_4ck159 = 0 time = 1600
.meas tran vdout0_4ck159 FIND v(dout0_4) AT=1600.05n

* CHECK dout0_5 Vdout0_5ck159 = 3.3 time = 1600
.meas tran vdout0_5ck159 FIND v(dout0_5) AT=1600.05n

* CHECK dout0_6 Vdout0_6ck159 = 3.3 time = 1600
.meas tran vdout0_6ck159 FIND v(dout0_6) AT=1600.05n

* CHECK dout0_7 Vdout0_7ck159 = 0 time = 1600
.meas tran vdout0_7ck159 FIND v(dout0_7) AT=1600.05n

* CHECK dout0_0 Vdout0_0ck162 = 3.3 time = 1630
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=1630.05n

* CHECK dout0_1 Vdout0_1ck162 = 0 time = 1630
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=1630.05n

* CHECK dout0_2 Vdout0_2ck162 = 3.3 time = 1630
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=1630.05n

* CHECK dout0_3 Vdout0_3ck162 = 3.3 time = 1630
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=1630.05n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 1630
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=1630.05n

* CHECK dout0_5 Vdout0_5ck162 = 0 time = 1630
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=1630.05n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 1630
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=1630.05n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 1630
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=1630.05n

* CHECK dout0_0 Vdout0_0ck164 = 3.3 time = 1650
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=1650.05n

* CHECK dout0_1 Vdout0_1ck164 = 3.3 time = 1650
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=1650.05n

* CHECK dout0_2 Vdout0_2ck164 = 3.3 time = 1650
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=1650.05n

* CHECK dout0_3 Vdout0_3ck164 = 0 time = 1650
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=1650.05n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 1650
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=1650.05n

* CHECK dout0_5 Vdout0_5ck164 = 3.3 time = 1650
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=1650.05n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 1650
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=1650.05n

* CHECK dout0_7 Vdout0_7ck164 = 0 time = 1650
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=1650.05n

* CHECK dout0_0 Vdout0_0ck165 = 3.3 time = 1660
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=1660.05n

* CHECK dout0_1 Vdout0_1ck165 = 3.3 time = 1660
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=1660.05n

* CHECK dout0_2 Vdout0_2ck165 = 3.3 time = 1660
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=1660.05n

* CHECK dout0_3 Vdout0_3ck165 = 0 time = 1660
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=1660.05n

* CHECK dout0_4 Vdout0_4ck165 = 0 time = 1660
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=1660.05n

* CHECK dout0_5 Vdout0_5ck165 = 3.3 time = 1660
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=1660.05n

* CHECK dout0_6 Vdout0_6ck165 = 0 time = 1660
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=1660.05n

* CHECK dout0_7 Vdout0_7ck165 = 0 time = 1660
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=1660.05n

* CHECK dout0_0 Vdout0_0ck166 = 3.3 time = 1670
.meas tran vdout0_0ck166 FIND v(dout0_0) AT=1670.05n

* CHECK dout0_1 Vdout0_1ck166 = 0 time = 1670
.meas tran vdout0_1ck166 FIND v(dout0_1) AT=1670.05n

* CHECK dout0_2 Vdout0_2ck166 = 3.3 time = 1670
.meas tran vdout0_2ck166 FIND v(dout0_2) AT=1670.05n

* CHECK dout0_3 Vdout0_3ck166 = 3.3 time = 1670
.meas tran vdout0_3ck166 FIND v(dout0_3) AT=1670.05n

* CHECK dout0_4 Vdout0_4ck166 = 0 time = 1670
.meas tran vdout0_4ck166 FIND v(dout0_4) AT=1670.05n

* CHECK dout0_5 Vdout0_5ck166 = 0 time = 1670
.meas tran vdout0_5ck166 FIND v(dout0_5) AT=1670.05n

* CHECK dout0_6 Vdout0_6ck166 = 0 time = 1670
.meas tran vdout0_6ck166 FIND v(dout0_6) AT=1670.05n

* CHECK dout0_7 Vdout0_7ck166 = 0 time = 1670
.meas tran vdout0_7ck166 FIND v(dout0_7) AT=1670.05n

* CHECK dout0_0 Vdout0_0ck169 = 3.3 time = 1700
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=1700.05n

* CHECK dout0_1 Vdout0_1ck169 = 3.3 time = 1700
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=1700.05n

* CHECK dout0_2 Vdout0_2ck169 = 3.3 time = 1700
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=1700.05n

* CHECK dout0_3 Vdout0_3ck169 = 0 time = 1700
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=1700.05n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 1700
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=1700.05n

* CHECK dout0_5 Vdout0_5ck169 = 3.3 time = 1700
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=1700.05n

* CHECK dout0_6 Vdout0_6ck169 = 0 time = 1700
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=1700.05n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 1700
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=1700.05n

* CHECK dout0_0 Vdout0_0ck170 = 3.3 time = 1710
.meas tran vdout0_0ck170 FIND v(dout0_0) AT=1710.05n

* CHECK dout0_1 Vdout0_1ck170 = 3.3 time = 1710
.meas tran vdout0_1ck170 FIND v(dout0_1) AT=1710.05n

* CHECK dout0_2 Vdout0_2ck170 = 3.3 time = 1710
.meas tran vdout0_2ck170 FIND v(dout0_2) AT=1710.05n

* CHECK dout0_3 Vdout0_3ck170 = 0 time = 1710
.meas tran vdout0_3ck170 FIND v(dout0_3) AT=1710.05n

* CHECK dout0_4 Vdout0_4ck170 = 0 time = 1710
.meas tran vdout0_4ck170 FIND v(dout0_4) AT=1710.05n

* CHECK dout0_5 Vdout0_5ck170 = 3.3 time = 1710
.meas tran vdout0_5ck170 FIND v(dout0_5) AT=1710.05n

* CHECK dout0_6 Vdout0_6ck170 = 0 time = 1710
.meas tran vdout0_6ck170 FIND v(dout0_6) AT=1710.05n

* CHECK dout0_7 Vdout0_7ck170 = 0 time = 1710
.meas tran vdout0_7ck170 FIND v(dout0_7) AT=1710.05n

* CHECK dout0_0 Vdout0_0ck171 = 3.3 time = 1720
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=1720.05n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 1720
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=1720.05n

* CHECK dout0_2 Vdout0_2ck171 = 3.3 time = 1720
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=1720.05n

* CHECK dout0_3 Vdout0_3ck171 = 3.3 time = 1720
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=1720.05n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 1720
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=1720.05n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 1720
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=1720.05n

* CHECK dout0_6 Vdout0_6ck171 = 0 time = 1720
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=1720.05n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 1720
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=1720.05n

* CHECK dout0_0 Vdout0_0ck172 = 3.3 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 3.3 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 3.3 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 0 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 0 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck173 = 3.3 time = 1740
.meas tran vdout0_0ck173 FIND v(dout0_0) AT=1740.05n

* CHECK dout0_1 Vdout0_1ck173 = 3.3 time = 1740
.meas tran vdout0_1ck173 FIND v(dout0_1) AT=1740.05n

* CHECK dout0_2 Vdout0_2ck173 = 3.3 time = 1740
.meas tran vdout0_2ck173 FIND v(dout0_2) AT=1740.05n

* CHECK dout0_3 Vdout0_3ck173 = 0 time = 1740
.meas tran vdout0_3ck173 FIND v(dout0_3) AT=1740.05n

* CHECK dout0_4 Vdout0_4ck173 = 0 time = 1740
.meas tran vdout0_4ck173 FIND v(dout0_4) AT=1740.05n

* CHECK dout0_5 Vdout0_5ck173 = 3.3 time = 1740
.meas tran vdout0_5ck173 FIND v(dout0_5) AT=1740.05n

* CHECK dout0_6 Vdout0_6ck173 = 0 time = 1740
.meas tran vdout0_6ck173 FIND v(dout0_6) AT=1740.05n

* CHECK dout0_7 Vdout0_7ck173 = 0 time = 1740
.meas tran vdout0_7ck173 FIND v(dout0_7) AT=1740.05n

* CHECK dout0_0 Vdout0_0ck175 = 3.3 time = 1760
.meas tran vdout0_0ck175 FIND v(dout0_0) AT=1760.05n

* CHECK dout0_1 Vdout0_1ck175 = 0 time = 1760
.meas tran vdout0_1ck175 FIND v(dout0_1) AT=1760.05n

* CHECK dout0_2 Vdout0_2ck175 = 3.3 time = 1760
.meas tran vdout0_2ck175 FIND v(dout0_2) AT=1760.05n

* CHECK dout0_3 Vdout0_3ck175 = 3.3 time = 1760
.meas tran vdout0_3ck175 FIND v(dout0_3) AT=1760.05n

* CHECK dout0_4 Vdout0_4ck175 = 0 time = 1760
.meas tran vdout0_4ck175 FIND v(dout0_4) AT=1760.05n

* CHECK dout0_5 Vdout0_5ck175 = 0 time = 1760
.meas tran vdout0_5ck175 FIND v(dout0_5) AT=1760.05n

* CHECK dout0_6 Vdout0_6ck175 = 0 time = 1760
.meas tran vdout0_6ck175 FIND v(dout0_6) AT=1760.05n

* CHECK dout0_7 Vdout0_7ck175 = 0 time = 1760
.meas tran vdout0_7ck175 FIND v(dout0_7) AT=1760.05n

* CHECK dout0_0 Vdout0_0ck176 = 3.3 time = 1770
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=1770.05n

* CHECK dout0_1 Vdout0_1ck176 = 3.3 time = 1770
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=1770.05n

* CHECK dout0_2 Vdout0_2ck176 = 3.3 time = 1770
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=1770.05n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 1770
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=1770.05n

* CHECK dout0_4 Vdout0_4ck176 = 0 time = 1770
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=1770.05n

* CHECK dout0_5 Vdout0_5ck176 = 3.3 time = 1770
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=1770.05n

* CHECK dout0_6 Vdout0_6ck176 = 0 time = 1770
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=1770.05n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 1770
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=1770.05n

* CHECK dout0_0 Vdout0_0ck178 = 0 time = 1790
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=1790.05n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 1790
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=1790.05n

* CHECK dout0_2 Vdout0_2ck178 = 0 time = 1790
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=1790.05n

* CHECK dout0_3 Vdout0_3ck178 = 3.3 time = 1790
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=1790.05n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 1790
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=1790.05n

* CHECK dout0_5 Vdout0_5ck178 = 3.3 time = 1790
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=1790.05n

* CHECK dout0_6 Vdout0_6ck178 = 3.3 time = 1790
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=1790.05n

* CHECK dout0_7 Vdout0_7ck178 = 3.3 time = 1790
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=1790.05n

* CHECK dout0_0 Vdout0_0ck188 = 3.3 time = 1890
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=1890.05n

* CHECK dout0_1 Vdout0_1ck188 = 3.3 time = 1890
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=1890.05n

* CHECK dout0_2 Vdout0_2ck188 = 3.3 time = 1890
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=1890.05n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 1890
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=1890.05n

* CHECK dout0_4 Vdout0_4ck188 = 3.3 time = 1890
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=1890.05n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 1890
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=1890.05n

* CHECK dout0_6 Vdout0_6ck188 = 3.3 time = 1890
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=1890.05n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 1890
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=1890.05n

* CHECK dout0_0 Vdout0_0ck192 = 0 time = 1930
.meas tran vdout0_0ck192 FIND v(dout0_0) AT=1930.05n

* CHECK dout0_1 Vdout0_1ck192 = 3.3 time = 1930
.meas tran vdout0_1ck192 FIND v(dout0_1) AT=1930.05n

* CHECK dout0_2 Vdout0_2ck192 = 3.3 time = 1930
.meas tran vdout0_2ck192 FIND v(dout0_2) AT=1930.05n

* CHECK dout0_3 Vdout0_3ck192 = 3.3 time = 1930
.meas tran vdout0_3ck192 FIND v(dout0_3) AT=1930.05n

* CHECK dout0_4 Vdout0_4ck192 = 3.3 time = 1930
.meas tran vdout0_4ck192 FIND v(dout0_4) AT=1930.05n

* CHECK dout0_5 Vdout0_5ck192 = 3.3 time = 1930
.meas tran vdout0_5ck192 FIND v(dout0_5) AT=1930.05n

* CHECK dout0_6 Vdout0_6ck192 = 3.3 time = 1930
.meas tran vdout0_6ck192 FIND v(dout0_6) AT=1930.05n

* CHECK dout0_7 Vdout0_7ck192 = 3.3 time = 1930
.meas tran vdout0_7ck192 FIND v(dout0_7) AT=1930.05n

* CHECK dout0_0 Vdout0_0ck193 = 3.3 time = 1940
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=1940.05n

* CHECK dout0_1 Vdout0_1ck193 = 3.3 time = 1940
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=1940.05n

* CHECK dout0_2 Vdout0_2ck193 = 3.3 time = 1940
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=1940.05n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 1940
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=1940.05n

* CHECK dout0_4 Vdout0_4ck193 = 3.3 time = 1940
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=1940.05n

* CHECK dout0_5 Vdout0_5ck193 = 0 time = 1940
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=1940.05n

* CHECK dout0_6 Vdout0_6ck193 = 3.3 time = 1940
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=1940.05n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 1940
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=1940.05n

* CHECK dout0_0 Vdout0_0ck200 = 3.3 time = 2010
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=2010.05n

* CHECK dout0_1 Vdout0_1ck200 = 3.3 time = 2010
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=2010.05n

* CHECK dout0_2 Vdout0_2ck200 = 0 time = 2010
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=2010.05n

* CHECK dout0_3 Vdout0_3ck200 = 3.3 time = 2010
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=2010.05n

* CHECK dout0_4 Vdout0_4ck200 = 3.3 time = 2010
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=2010.05n

* CHECK dout0_5 Vdout0_5ck200 = 3.3 time = 2010
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=2010.05n

* CHECK dout0_6 Vdout0_6ck200 = 3.3 time = 2010
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=2010.05n

* CHECK dout0_7 Vdout0_7ck200 = 3.3 time = 2010
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=2010.05n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
