* Functional test stimulus file for 10ns period

* TT process corner
.include "/Users/seandoyle/NYU/classes/ProcessorDesign/openram/technology/scn4m_subm/models/nom/pmos.sp"
.include "/Users/seandoyle/NYU/classes/ProcessorDesign/openram/technology/scn4m_subm/models/nom/nmos.sp"
.include "ROM_Mem.sp"

* Global Power Supplies
Vvdd vdd 0 3.3

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
XROM_Mem din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 a0_0 a0_1 a0_2 a0_3 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 vdd gnd ROM_Mem

* SRAM output loads
CD00 dout0_0  0 39.2968f
CD01 dout0_1  0 39.2968f
CD02 dout0_2  0 39.2968f
CD03 dout0_3  0 39.2968f
CD04 dout0_4  0 39.2968f
CD05 dout0_5  0 39.2968f
CD06 dout0_6  0 39.2968f
CD07 dout0_7  0 39.2968f

* Important signals for debug
* bl:	xrom_mem.xbank0.bl_0_0
* br:	xrom_mem.xbank0.br_0_0
* s_en:	xrom_mem.s_en
* q:	xROM_Mem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xROM_Mem.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 10ns)
*	Writing 01100001  to  address 1110 (from port 0) during cycle 1 (10ns - 20ns)
*	Writing 11111101  to  address 0000 (from port 0) during cycle 2 (20ns - 30ns)
*	Writing 10000010  to  address 1110 (from port 0) during cycle 3 (30ns - 40ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 4 (40ns - 50ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 5 (50ns - 60ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 6 (60ns - 70ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 8 (80ns - 90ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 9 (90ns - 100ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 10 (100ns - 110ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 12 (120ns - 130ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 13 (130ns - 140ns)
*	Reading 11111101 from address 0000 (from port 0) during cycle 14 (140ns - 150ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 15 (150ns - 160ns)
*	Reading 10000010 from address 1110 (from port 0) during cycle 16 (160ns - 170ns)
*	Writing 00100011  to  address 1110 (from port 0) during cycle 17 (170ns - 180ns)
*	Writing 00111110  to  address 1110 (from port 0) during cycle 18 (180ns - 190ns)
*	Writing 00100110  to  address 1110 (from port 0) during cycle 19 (190ns - 200ns)
*	Writing 00101011  to  address 0000 (from port 0) during cycle 20 (200ns - 210ns)
*	Reading 00100110 from address 1110 (from port 0) during cycle 23 (230ns - 240ns)
*	Writing 11111001  to  address 0000 (from port 0) during cycle 24 (240ns - 250ns)
*	Reading 00100110 from address 1110 (from port 0) during cycle 26 (260ns - 270ns)
*	Reading 00100110 from address 1110 (from port 0) during cycle 29 (290ns - 300ns)
*	Reading 11111001 from address 0000 (from port 0) during cycle 32 (320ns - 330ns)
*	Writing 01110111  to  address 1110 (from port 0) during cycle 33 (330ns - 340ns)
*	Writing 01010111  to  address 1110 (from port 0) during cycle 35 (350ns - 360ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 36 (360ns - 370ns)
*	Writing 11100001  to  address 0000 (from port 0) during cycle 37 (370ns - 380ns)
*	Reading 11100001 from address 0000 (from port 0) during cycle 38 (380ns - 390ns)
*	Reading 11100001 from address 0000 (from port 0) during cycle 39 (390ns - 400ns)
*	Reading 11100001 from address 0000 (from port 0) during cycle 40 (400ns - 410ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 41 (410ns - 420ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 42 (420ns - 430ns)
*	Reading 11100001 from address 0000 (from port 0) during cycle 43 (430ns - 440ns)
*	Writing 01111010  to  address 0000 (from port 0) during cycle 44 (440ns - 450ns)
*	Reading 01111010 from address 0000 (from port 0) during cycle 45 (450ns - 460ns)
*	Writing 11101100  to  address 0000 (from port 0) during cycle 46 (460ns - 470ns)
*	Reading 11101100 from address 0000 (from port 0) during cycle 47 (470ns - 480ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 49 (490ns - 500ns)
*	Writing 11110011  to  address 0000 (from port 0) during cycle 51 (510ns - 520ns)
*	Reading 11110011 from address 0000 (from port 0) during cycle 52 (520ns - 530ns)
*	Reading 11110011 from address 0000 (from port 0) during cycle 53 (530ns - 540ns)
*	Reading 11110011 from address 0000 (from port 0) during cycle 54 (540ns - 550ns)
*	Reading 01010111 from address 1110 (from port 0) during cycle 55 (550ns - 560ns)
*	Writing 11100101  to  address 0000 (from port 0) during cycle 56 (560ns - 570ns)
*	Reading 11100101 from address 0000 (from port 0) during cycle 60 (600ns - 610ns)
*	Writing 11010101  to  address 1110 (from port 0) during cycle 61 (610ns - 620ns)
*	Writing 00001111  to  address 0000 (from port 0) during cycle 62 (620ns - 630ns)
*	Reading 11010101 from address 1110 (from port 0) during cycle 64 (640ns - 650ns)
*	Writing 00110010  to  address 1110 (from port 0) during cycle 65 (650ns - 660ns)
*	Reading 00110010 from address 1110 (from port 0) during cycle 67 (670ns - 680ns)
*	Writing 01011001  to  address 0000 (from port 0) during cycle 68 (680ns - 690ns)
*	Reading 00110010 from address 1110 (from port 0) during cycle 71 (710ns - 720ns)
*	Reading 00110010 from address 1110 (from port 0) during cycle 72 (720ns - 730ns)
*	Writing 11110101  to  address 0000 (from port 0) during cycle 75 (750ns - 760ns)
*	Writing 11010001  to  address 1110 (from port 0) during cycle 76 (760ns - 770ns)
*	Writing 00110111  to  address 1110 (from port 0) during cycle 77 (770ns - 780ns)
*	Writing 00000011  to  address 0000 (from port 0) during cycle 78 (780ns - 790ns)
*	Reading 00000011 from address 0000 (from port 0) during cycle 79 (790ns - 800ns)
*	Writing 01000101  to  address 0000 (from port 0) during cycle 80 (800ns - 810ns)
*	Reading 01000101 from address 0000 (from port 0) during cycle 83 (830ns - 840ns)
*	Writing 01011000  to  address 0000 (from port 0) during cycle 84 (840ns - 850ns)
*	Reading 01011000 from address 0000 (from port 0) during cycle 85 (850ns - 860ns)
*	Writing 01100001  to  address 0000 (from port 0) during cycle 87 (870ns - 880ns)
*	Reading 01100001 from address 0000 (from port 0) during cycle 88 (880ns - 890ns)
*	Writing 01100010  to  address 1110 (from port 0) during cycle 89 (890ns - 900ns)
*	Writing 10110110  to  address 1110 (from port 0) during cycle 90 (900ns - 910ns)
*	Reading 01100001 from address 0000 (from port 0) during cycle 92 (920ns - 930ns)
*	Reading 01100001 from address 0000 (from port 0) during cycle 95 (950ns - 960ns)
*	Reading 10110110 from address 1110 (from port 0) during cycle 96 (960ns - 970ns)
*	Reading 01100001 from address 0000 (from port 0) during cycle 97 (970ns - 980ns)
*	Reading 01100001 from address 0000 (from port 0) during cycle 98 (980ns - 990ns)
*	Reading 10110110 from address 1110 (from port 0) during cycle 99 (990ns - 1000ns)
*	Writing 10101010  to  address 0000 (from port 0) during cycle 100 (1000ns - 1010ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 101 (1010ns - 1020ns)
*	Writing 01001101  to  address 1110 (from port 0) during cycle 104 (1040ns - 1050ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 105 (1050ns - 1060ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 106 (1060ns - 1070ns)
*	Writing 11010101  to  address 1110 (from port 0) during cycle 107 (1070ns - 1080ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 108 (1080ns - 1090ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 109 (1090ns - 1100ns)
*	Reading 11010101 from address 1110 (from port 0) during cycle 110 (1100ns - 1110ns)
*	Reading 11010101 from address 1110 (from port 0) during cycle 112 (1120ns - 1130ns)
*	Writing 00011111  to  address 1110 (from port 0) during cycle 113 (1130ns - 1140ns)
*	Reading 10101010 from address 0000 (from port 0) during cycle 114 (1140ns - 1150ns)
*	Reading 00011111 from address 1110 (from port 0) during cycle 117 (1170ns - 1180ns)
*	Writing 10011000  to  address 0000 (from port 0) during cycle 118 (1180ns - 1190ns)
*	Writing 00000110  to  address 0000 (from port 0) during cycle 119 (1190ns - 1200ns)
*	Reading 00000110 from address 0000 (from port 0) during cycle 120 (1200ns - 1210ns)
*	Writing 10100010  to  address 0000 (from port 0) during cycle 121 (1210ns - 1220ns)
*	Writing 10010000  to  address 0000 (from port 0) during cycle 122 (1220ns - 1230ns)
*	Writing 11000101  to  address 0000 (from port 0) during cycle 123 (1230ns - 1240ns)
*	Writing 10001010  to  address 0000 (from port 0) during cycle 125 (1250ns - 1260ns)
*	Reading 00011111 from address 1110 (from port 0) during cycle 126 (1260ns - 1270ns)
*	Reading 00011111 from address 1110 (from port 0) during cycle 127 (1270ns - 1280ns)
*	Writing 11011100  to  address 1110 (from port 0) during cycle 128 (1280ns - 1290ns)
*	Writing 01111011  to  address 0000 (from port 0) during cycle 129 (1290ns - 1300ns)
*	Reading 01111011 from address 0000 (from port 0) during cycle 130 (1300ns - 1310ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 131 (1310ns - 1320ns)
*	Reading 01111011 from address 0000 (from port 0) during cycle 132 (1320ns - 1330ns)
*	Reading 01111011 from address 0000 (from port 0) during cycle 133 (1330ns - 1340ns)
*	Reading 11011100 from address 1110 (from port 0) during cycle 134 (1340ns - 1350ns)
*	Writing 01010000  to  address 1110 (from port 0) during cycle 135 (1350ns - 1360ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 136 (1360ns - 1370ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 137 (1370ns - 1380ns)
*	Reading 01111011 from address 0000 (from port 0) during cycle 138 (1380ns - 1390ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 139 (1390ns - 1400ns)
*	Writing 11000000  to  address 0000 (from port 0) during cycle 140 (1400ns - 1410ns)
*	Writing 10101010  to  address 0000 (from port 0) during cycle 141 (1410ns - 1420ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 142 (1420ns - 1430ns)
*	Writing 01000001  to  address 0000 (from port 0) during cycle 143 (1430ns - 1440ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 144 (1440ns - 1450ns)
*	Reading 01000001 from address 0000 (from port 0) during cycle 146 (1460ns - 1470ns)
*	Reading 01000001 from address 0000 (from port 0) during cycle 147 (1470ns - 1480ns)
*	Reading 01000001 from address 0000 (from port 0) during cycle 148 (1480ns - 1490ns)
*	Reading 01000001 from address 0000 (from port 0) during cycle 149 (1490ns - 1500ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 150 (1500ns - 1510ns)
*	Reading 01010000 from address 1110 (from port 0) during cycle 151 (1510ns - 1520ns)
*	Writing 11010001  to  address 1110 (from port 0) during cycle 152 (1520ns - 1530ns)
*	Reading 11010001 from address 1110 (from port 0) during cycle 153 (1530ns - 1540ns)
*	Reading 01000001 from address 0000 (from port 0) during cycle 154 (1540ns - 1550ns)
*	Reading 11010001 from address 1110 (from port 0) during cycle 155 (1550ns - 1560ns)
*	Writing 00101010  to  address 0000 (from port 0) during cycle 156 (1560ns - 1570ns)
*	Writing 11111010  to  address 1110 (from port 0) during cycle 157 (1570ns - 1580ns)
*	Writing 10001111  to  address 1110 (from port 0) during cycle 158 (1580ns - 1590ns)
*	Reading 00101010 from address 0000 (from port 0) during cycle 160 (1600ns - 1610ns)
*	Reading 00101010 from address 0000 (from port 0) during cycle 161 (1610ns - 1620ns)
*	Reading 00101010 from address 0000 (from port 0) during cycle 163 (1630ns - 1640ns)
*	Reading 10001111 from address 1110 (from port 0) during cycle 164 (1640ns - 1650ns)
*	Writing 11110010  to  address 1110 (from port 0) during cycle 165 (1650ns - 1660ns)
*	Writing 11100111  to  address 0000 (from port 0) during cycle 166 (1660ns - 1670ns)
*	Writing 01110101  to  address 0000 (from port 0) during cycle 167 (1670ns - 1680ns)
*	Reading 01110101 from address 0000 (from port 0) during cycle 168 (1680ns - 1690ns)
*	Writing 11111001  to  address 1110 (from port 0) during cycle 169 (1690ns - 1700ns)
*	Writing 00100000  to  address 1110 (from port 0) during cycle 170 (1700ns - 1710ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 171 (1710ns - 1720ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 172 (1720ns - 1730ns)
*	Writing 01011110  to  address 0000 (from port 0) during cycle 173 (1730ns - 1740ns)
*	Writing 10001111  to  address 0000 (from port 0) during cycle 175 (1750ns - 1760ns)
*	Writing 00101010  to  address 0000 (from port 0) during cycle 176 (1760ns - 1770ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 177 (1770ns - 1780ns)
*	Writing 00001100  to  address 0000 (from port 0) during cycle 179 (1790ns - 1800ns)
*	Reading 00001100 from address 0000 (from port 0) during cycle 181 (1810ns - 1820ns)
*	Writing 00010111  to  address 0000 (from port 0) during cycle 183 (1830ns - 1840ns)
*	Reading 00010111 from address 0000 (from port 0) during cycle 184 (1840ns - 1850ns)
*	Writing 10110101  to  address 0000 (from port 0) during cycle 185 (1850ns - 1860ns)
*	Reading 10110101 from address 0000 (from port 0) during cycle 186 (1860ns - 1870ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 187 (1870ns - 1880ns)
*	Reading 10110101 from address 0000 (from port 0) during cycle 190 (1900ns - 1910ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 193 (1930ns - 1940ns)
*	Reading 00100000 from address 1110 (from port 0) during cycle 195 (1950ns - 1960ns)
*	Reading 10110101 from address 0000 (from port 0) during cycle 196 (1960ns - 1970ns)
*	Reading 10110101 from address 0000 (from port 0) during cycle 197 (1970ns - 1980ns)
*	Writing 01101110  to  address 0000 (from port 0) during cycle 198 (1980ns - 1990ns)
*	Reading 01101110 from address 0000 (from port 0) during cycle 199 (1990ns - 2000ns)
*	Reading 01101110 from address 0000 (from port 0) during cycle 200 (2000ns - 2010ns)
*	Writing 00100000  to  address 1110 (from port 0) during cycle 201 (2010ns - 2020ns)
*	Writing 01101010  to  address 1110 (from port 0) during cycle 202 (2020ns - 2030ns)
*	Reading 01101110 from address 0000 (from port 0) during cycle 203 (2030ns - 2040ns)
*	Reading 01101010 from address 1110 (from port 0) during cycle 204 (2040ns - 2050ns)
*	Idle during cycle 205 (2050ns - 2060ns)

* Generation of data and address signals
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 0), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 1), (790, 1), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 3.3v 179.45n 3.3v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 1), (780, 1), (790, 1), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 3.3v 779.45n 3.3v 779.55n 3.3v 789.45n 3.3v 789.55n 3.3v 799.45n 3.3v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 1), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 1), (1200, 1), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 1), (1670, 1), (1680, 1), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 0.0v 769.45n 0.0v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 3.3v 1199.45n 3.3v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 0), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 1), (630, 1), (640, 1), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 1), (1050, 1), (1060, 1), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 1), (1760, 1), (1770, 1), (1780, 1), (1790, 1), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 0.0v 199.45n 0.0v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 3.3v 629.45n 3.3v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 3.3v 1799.45n 3.3v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 1), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 1), (450, 1), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 1), (850, 1), (860, 1), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 1), (1190, 0), (1200, 0), (1210, 0), (1220, 1), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 0), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 1), (1840, 1), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 3.3v 189.45n 3.3v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 3.3v 1839.45n 3.3v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 1), (180, 1), (190, 1), (200, 1), (210, 1), (220, 1), (230, 1), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 0), (640, 0), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 0), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 1), (880, 1), (890, 1), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 1), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 1), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 1), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 1), (1990, 1), (2000, 1), (2010, 1), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 3.3v 209.45n 3.3v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 0.0v 769.45n 0.0v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 3.3v 1569.45n 3.3v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 3.3v 1769.45n 3.3v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 1), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 1), (340, 1), (350, 1), (360, 1), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 1), (450, 1), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 1), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 1), (810, 1), (820, 1), (830, 1), (840, 1), (850, 1), (860, 1), (870, 1), (880, 1), (890, 1), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 1), (1060, 1), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 1), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 1), (1290, 1), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 1), (1410, 0), (1420, 0), (1430, 1), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 1), (1660, 1), (1670, 1), (1680, 1), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 1), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 1), (1990, 1), (2000, 1), (2010, 0), (2020, 1), (2030, 1), (2040, 1), (2050, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 3.3v 29.45n 3.3v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 3.3v 379.45n 3.3v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 3.3v 449.45n 3.3v 449.55n 3.3v 459.45n 3.3v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 3.3v 689.45n 3.3v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 3.3v 809.45n 3.3v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 3.3v 849.45n 3.3v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 3.3v 879.45n 3.3v 879.55n 3.3v 889.45n 3.3v 889.55n 3.3v 899.45n 3.3v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 3.3v 1299.45n 3.3v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 3.3v 1439.45n 3.3v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 3.3v 1679.45n 3.3v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 3.3v 1739.45n 3.3v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 3.3v 1989.45n 3.3v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 0), (20, 1), (30, 1), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 1), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 0), (350, 0), (360, 0), (370, 1), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 0), (460, 1), (470, 1), (480, 1), (490, 1), (500, 1), (510, 1), (520, 1), (530, 1), (540, 1), (550, 1), (560, 1), (570, 1), (580, 1), (590, 1), (600, 1), (610, 1), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 1), (760, 1), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 1), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 1), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 1), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 1), (1190, 0), (1200, 0), (1210, 1), (1220, 1), (1230, 1), (1240, 1), (1250, 1), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 1), (1410, 1), (1420, 1), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 1), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 1), (1660, 1), (1670, 0), (1680, 0), (1690, 1), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 1), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 1), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 3.3v 29.45n 3.3v 29.55n 3.3v 39.45n 3.3v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 3.3v 249.45n 3.3v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 3.3v 379.45n 3.3v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 3.3v 469.45n 3.3v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 3.3v 519.45n 3.3v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 3.3v 569.45n 3.3v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 3.3v 759.45n 3.3v 759.55n 3.3v 769.45n 3.3v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 3.3v 1009.45n 3.3v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 3.3v 1189.45n 3.3v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 3.3v 1219.45n 3.3v 1219.55n 3.3v 1229.45n 3.3v 1229.55n 3.3v 1239.45n 3.3v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 3.3v 1259.45n 3.3v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 3.3v 1409.45n 3.3v 1409.55n 3.3v 1419.45n 3.3v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 3.3v 1669.45n 3.3v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 3.3v 1759.45n 3.3v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 3.3v 1859.45n 3.3v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 0), (80, 0), (90, 0), (100, 0), (110, 0), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 0), (220, 0), (230, 0), (240, 0), (250, 0), (260, 0), (270, 0), (280, 0), (290, 0), (300, 0), (310, 0), (320, 0), (330, 0), (340, 0), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 0), (500, 0), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 0), (620, 0), (630, 0), (640, 0), (650, 0), (660, 0), (670, 0), (680, 0), (690, 0), (700, 0), (710, 0), (720, 0), (730, 0), (740, 0), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 0), (900, 0), (910, 0), (920, 0), (930, 0), (940, 0), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 0), (1120, 0), (1130, 0), (1140, 0), (1150, 0), (1160, 0), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 0), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 0), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 0), (1780, 0), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 0), (1890, 0), (1900, 0), (1910, 0), (1920, 0), (1930, 0), (1940, 0), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 0.0v 79.45n 0.0v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 0.0v 119.45n 0.0v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 0.0v 269.45n 0.0v 269.55n 0.0v 279.45n 0.0v 279.55n 0.0v 289.45n 0.0v 289.55n 0.0v 299.45n 0.0v 299.55n 0.0v 309.45n 0.0v 309.55n 0.0v 319.45n 0.0v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 0.0v 349.45n 0.0v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 0.0v 499.45n 0.0v 499.55n 0.0v 509.45n 0.0v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 0.0v 669.45n 0.0v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 0.0v 739.45n 0.0v 739.55n 0.0v 749.45n 0.0v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 0.0v 919.45n 0.0v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 0.0v 1119.45n 0.0v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 0.0v 1459.45n 0.0v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 0.0v 1599.45n 0.0v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 0.0v 1789.45n 0.0v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 0.0v 1889.45n 0.0v 1889.55n 0.0v 1899.45n 0.0v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 0.0v 1949.45n 0.0v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 0.0v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 0), (2040, 1), (2050, 1)]
Va0_1  a0_1  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 0), (2040, 1), (2050, 1)]
Va0_2  a0_2  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* (time, data): [(0, 0), (10, 1), (20, 0), (30, 1), (40, 0), (50, 1), (60, 1), (70, 1), (80, 0), (90, 0), (100, 1), (110, 1), (120, 0), (130, 0), (140, 0), (150, 1), (160, 1), (170, 1), (180, 1), (190, 1), (200, 0), (210, 0), (220, 0), (230, 1), (240, 0), (250, 0), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 0), (330, 1), (340, 1), (350, 1), (360, 1), (370, 0), (380, 0), (390, 0), (400, 0), (410, 1), (420, 1), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 0), (490, 1), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 1), (560, 0), (570, 0), (580, 0), (590, 0), (600, 0), (610, 1), (620, 0), (630, 0), (640, 1), (650, 1), (660, 1), (670, 1), (680, 0), (690, 0), (700, 0), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 1), (770, 1), (780, 0), (790, 0), (800, 0), (810, 0), (820, 0), (830, 0), (840, 0), (850, 0), (860, 0), (870, 0), (880, 0), (890, 1), (900, 1), (910, 1), (920, 0), (930, 0), (940, 0), (950, 0), (960, 1), (970, 0), (980, 0), (990, 1), (1000, 0), (1010, 0), (1020, 0), (1030, 0), (1040, 1), (1050, 0), (1060, 0), (1070, 1), (1080, 0), (1090, 0), (1100, 1), (1110, 1), (1120, 1), (1130, 1), (1140, 0), (1150, 0), (1160, 0), (1170, 1), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 0), (1250, 0), (1260, 1), (1270, 1), (1280, 1), (1290, 0), (1300, 0), (1310, 1), (1320, 0), (1330, 0), (1340, 1), (1350, 1), (1360, 1), (1370, 1), (1380, 0), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 1), (1510, 1), (1520, 1), (1530, 1), (1540, 0), (1550, 1), (1560, 0), (1570, 1), (1580, 1), (1590, 1), (1600, 0), (1610, 0), (1620, 0), (1630, 0), (1640, 1), (1650, 1), (1660, 0), (1670, 0), (1680, 0), (1690, 1), (1700, 1), (1710, 1), (1720, 1), (1730, 0), (1740, 0), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 0), (1810, 0), (1820, 0), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 1), (1880, 1), (1890, 1), (1900, 0), (1910, 0), (1920, 0), (1930, 1), (1940, 1), (1950, 1), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 1), (2020, 1), (2030, 0), (2040, 1), (2050, 1)]
Va0_3  a0_3  0 PWL (0n 0.0v 9.45n 0.0v 9.55n 3.3v 19.45n 3.3v 19.55n 0.0v 29.45n 0.0v 29.55n 3.3v 39.45n 3.3v 39.55n 0.0v 49.45n 0.0v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 3.3v 179.45n 3.3v 179.55n 3.3v 189.45n 3.3v 189.55n 3.3v 199.45n 3.3v 199.55n 0.0v 209.45n 0.0v 209.55n 0.0v 219.45n 0.0v 219.55n 0.0v 229.45n 0.0v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 0.0v 259.45n 0.0v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 3.3v 339.45n 3.3v 339.55n 3.3v 349.45n 3.3v 349.55n 3.3v 359.45n 3.3v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 0.0v 489.45n 0.0v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 0.0v 579.45n 0.0v 579.55n 0.0v 589.45n 0.0v 589.55n 0.0v 599.45n 0.0v 599.55n 0.0v 609.45n 0.0v 609.55n 3.3v 619.45n 3.3v 619.55n 0.0v 629.45n 0.0v 629.55n 0.0v 639.45n 0.0v 639.55n 3.3v 649.45n 3.3v 649.55n 3.3v 659.45n 3.3v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 0.0v 699.45n 0.0v 699.55n 0.0v 709.45n 0.0v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 3.3v 769.45n 3.3v 769.55n 3.3v 779.45n 3.3v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 0.0v 819.45n 0.0v 819.55n 0.0v 829.45n 0.0v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 0.0v 869.45n 0.0v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 3.3v 899.45n 3.3v 899.55n 3.3v 909.45n 3.3v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 0.0v 939.45n 0.0v 939.55n 0.0v 949.45n 0.0v 949.55n 0.0v 959.45n 0.0v 959.55n 3.3v 969.45n 3.3v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 0.0v 1029.45n 0.0v 1029.55n 0.0v 1039.45n 0.0v 1039.55n 3.3v 1049.45n 3.3v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 3.3v 1079.45n 3.3v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 3.3v 1139.45n 3.3v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 0.0v 1159.45n 0.0v 1159.55n 0.0v 1169.45n 0.0v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 0.0v 1249.45n 0.0v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 3.3v 1289.45n 3.3v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 3.3v 1359.45n 3.3v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 3.3v 1529.45n 3.3v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 3.3v 1579.45n 3.3v 1579.55n 3.3v 1589.45n 3.3v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 0.0v 1629.45n 0.0v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 3.3v 1659.45n 3.3v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 3.3v 1699.45n 3.3v 1699.55n 3.3v 1709.45n 3.3v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 0.0v 1749.45n 0.0v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 0.0v 1809.45n 0.0v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 0.0v 1829.45n 0.0v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 0.0v 1919.45n 0.0v 1919.55n 0.0v 1929.45n 0.0v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 3.3v 2019.45n 3.3v 2019.55n 3.3v 2029.45n 3.3v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )

 * Generation of control signals
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 0), (50, 0), (60, 0), (70, 1), (80, 0), (90, 0), (100, 0), (110, 1), (120, 0), (130, 0), (140, 0), (150, 0), (160, 0), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 0), (240, 0), (250, 1), (260, 0), (270, 1), (280, 1), (290, 0), (300, 1), (310, 1), (320, 0), (330, 0), (340, 1), (350, 0), (360, 0), (370, 0), (380, 0), (390, 0), (400, 0), (410, 0), (420, 0), (430, 0), (440, 0), (450, 0), (460, 0), (470, 0), (480, 1), (490, 0), (500, 1), (510, 0), (520, 0), (530, 0), (540, 0), (550, 0), (560, 0), (570, 1), (580, 1), (590, 1), (600, 0), (610, 0), (620, 0), (630, 1), (640, 0), (650, 0), (660, 1), (670, 0), (680, 0), (690, 1), (700, 1), (710, 0), (720, 0), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 0), (800, 0), (810, 1), (820, 1), (830, 0), (840, 0), (850, 0), (860, 1), (870, 0), (880, 0), (890, 0), (900, 0), (910, 1), (920, 0), (930, 1), (940, 1), (950, 0), (960, 0), (970, 0), (980, 0), (990, 0), (1000, 0), (1010, 0), (1020, 1), (1030, 1), (1040, 0), (1050, 0), (1060, 0), (1070, 0), (1080, 0), (1090, 0), (1100, 0), (1110, 1), (1120, 0), (1130, 0), (1140, 0), (1150, 1), (1160, 1), (1170, 0), (1180, 0), (1190, 0), (1200, 0), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 0), (1270, 0), (1280, 0), (1290, 0), (1300, 0), (1310, 0), (1320, 0), (1330, 0), (1340, 0), (1350, 0), (1360, 0), (1370, 0), (1380, 0), (1390, 0), (1400, 0), (1410, 0), (1420, 0), (1430, 0), (1440, 0), (1450, 1), (1460, 0), (1470, 0), (1480, 0), (1490, 0), (1500, 0), (1510, 0), (1520, 0), (1530, 0), (1540, 0), (1550, 0), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 0), (1610, 0), (1620, 1), (1630, 0), (1640, 0), (1650, 0), (1660, 0), (1670, 0), (1680, 0), (1690, 0), (1700, 0), (1710, 0), (1720, 0), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 0), (1780, 1), (1790, 0), (1800, 1), (1810, 0), (1820, 1), (1830, 0), (1840, 0), (1850, 0), (1860, 0), (1870, 0), (1880, 1), (1890, 1), (1900, 0), (1910, 1), (1920, 1), (1930, 0), (1940, 1), (1950, 0), (1960, 0), (1970, 0), (1980, 0), (1990, 0), (2000, 0), (2010, 0), (2020, 0), (2030, 0), (2040, 0), (2050, 1)]
VCSB0 CSB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 0.0v 49.45n 0.0v 49.55n 0.0v 59.45n 0.0v 59.55n 0.0v 69.45n 0.0v 69.55n 3.3v 79.45n 3.3v 79.55n 0.0v 89.45n 0.0v 89.55n 0.0v 99.45n 0.0v 99.55n 0.0v 109.45n 0.0v 109.55n 3.3v 119.45n 3.3v 119.55n 0.0v 129.45n 0.0v 129.55n 0.0v 139.45n 0.0v 139.55n 0.0v 149.45n 0.0v 149.55n 0.0v 159.45n 0.0v 159.55n 0.0v 169.45n 0.0v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 0.0v 239.45n 0.0v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 0.0v 269.45n 0.0v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 0.0v 299.45n 0.0v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 0.0v 329.45n 0.0v 329.55n 0.0v 339.45n 0.0v 339.55n 3.3v 349.45n 3.3v 349.55n 0.0v 359.45n 0.0v 359.55n 0.0v 369.45n 0.0v 369.55n 0.0v 379.45n 0.0v 379.55n 0.0v 389.45n 0.0v 389.55n 0.0v 399.45n 0.0v 399.55n 0.0v 409.45n 0.0v 409.55n 0.0v 419.45n 0.0v 419.55n 0.0v 429.45n 0.0v 429.55n 0.0v 439.45n 0.0v 439.55n 0.0v 449.45n 0.0v 449.55n 0.0v 459.45n 0.0v 459.55n 0.0v 469.45n 0.0v 469.55n 0.0v 479.45n 0.0v 479.55n 3.3v 489.45n 3.3v 489.55n 0.0v 499.45n 0.0v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 0.0v 529.45n 0.0v 529.55n 0.0v 539.45n 0.0v 539.55n 0.0v 549.45n 0.0v 549.55n 0.0v 559.45n 0.0v 559.55n 0.0v 569.45n 0.0v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 0.0v 609.45n 0.0v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 0.0v 649.45n 0.0v 649.55n 0.0v 659.45n 0.0v 659.55n 3.3v 669.45n 3.3v 669.55n 0.0v 679.45n 0.0v 679.55n 0.0v 689.45n 0.0v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 0.0v 719.45n 0.0v 719.55n 0.0v 729.45n 0.0v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 0.0v 799.45n 0.0v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 0.0v 839.45n 0.0v 839.55n 0.0v 849.45n 0.0v 849.55n 0.0v 859.45n 0.0v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 0.0v 889.45n 0.0v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 3.3v 919.45n 3.3v 919.55n 0.0v 929.45n 0.0v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 0.0v 959.45n 0.0v 959.55n 0.0v 969.45n 0.0v 969.55n 0.0v 979.45n 0.0v 979.55n 0.0v 989.45n 0.0v 989.55n 0.0v 999.45n 0.0v 999.55n 0.0v 1009.45n 0.0v 1009.55n 0.0v 1019.45n 0.0v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 0.0v 1059.45n 0.0v 1059.55n 0.0v 1069.45n 0.0v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 0.0v 1089.45n 0.0v 1089.55n 0.0v 1099.45n 0.0v 1099.55n 0.0v 1109.45n 0.0v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 0.0v 1129.45n 0.0v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 0.0v 1149.45n 0.0v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 0.0v 1179.45n 0.0v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 0.0v 1209.45n 0.0v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 0.0v 1269.45n 0.0v 1269.55n 0.0v 1279.45n 0.0v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 0.0v 1309.45n 0.0v 1309.55n 0.0v 1319.45n 0.0v 1319.55n 0.0v 1329.45n 0.0v 1329.55n 0.0v 1339.45n 0.0v 1339.55n 0.0v 1349.45n 0.0v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 0.0v 1369.45n 0.0v 1369.55n 0.0v 1379.45n 0.0v 1379.55n 0.0v 1389.45n 0.0v 1389.55n 0.0v 1399.45n 0.0v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 0.0v 1429.45n 0.0v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 0.0v 1449.45n 0.0v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 0.0v 1469.45n 0.0v 1469.55n 0.0v 1479.45n 0.0v 1479.55n 0.0v 1489.45n 0.0v 1489.55n 0.0v 1499.45n 0.0v 1499.55n 0.0v 1509.45n 0.0v 1509.55n 0.0v 1519.45n 0.0v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 0.0v 1539.45n 0.0v 1539.55n 0.0v 1549.45n 0.0v 1549.55n 0.0v 1559.45n 0.0v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 0.0v 1609.45n 0.0v 1609.55n 0.0v 1619.45n 0.0v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 0.0v 1639.45n 0.0v 1639.55n 0.0v 1649.45n 0.0v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 0.0v 1689.45n 0.0v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 0.0v 1719.45n 0.0v 1719.55n 0.0v 1729.45n 0.0v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 0.0v 1779.45n 0.0v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 0.0v 1819.45n 0.0v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 0.0v 1849.45n 0.0v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 0.0v 1869.45n 0.0v 1869.55n 0.0v 1879.45n 0.0v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 0.0v 1909.45n 0.0v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 0.0v 1939.45n 0.0v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 0.0v 1959.45n 0.0v 1959.55n 0.0v 1969.45n 0.0v 1969.55n 0.0v 1979.45n 0.0v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 0.0v 1999.45n 0.0v 1999.55n 0.0v 2009.45n 0.0v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 0.0v 2039.45n 0.0v 2039.55n 0.0v 2049.45n 0.0v 2049.55n 3.3v )
* (time, data): [(0, 1), (10, 0), (20, 0), (30, 0), (40, 1), (50, 1), (60, 1), (70, 1), (80, 1), (90, 1), (100, 1), (110, 1), (120, 1), (130, 1), (140, 1), (150, 1), (160, 1), (170, 0), (180, 0), (190, 0), (200, 0), (210, 1), (220, 1), (230, 1), (240, 0), (250, 1), (260, 1), (270, 1), (280, 1), (290, 1), (300, 1), (310, 1), (320, 1), (330, 0), (340, 1), (350, 0), (360, 1), (370, 0), (380, 1), (390, 1), (400, 1), (410, 1), (420, 1), (430, 1), (440, 0), (450, 1), (460, 0), (470, 1), (480, 1), (490, 1), (500, 1), (510, 0), (520, 1), (530, 1), (540, 1), (550, 1), (560, 0), (570, 1), (580, 1), (590, 1), (600, 1), (610, 0), (620, 0), (630, 1), (640, 1), (650, 0), (660, 1), (670, 1), (680, 0), (690, 1), (700, 1), (710, 1), (720, 1), (730, 1), (740, 1), (750, 0), (760, 0), (770, 0), (780, 0), (790, 1), (800, 0), (810, 1), (820, 1), (830, 1), (840, 0), (850, 1), (860, 1), (870, 0), (880, 1), (890, 0), (900, 0), (910, 1), (920, 1), (930, 1), (940, 1), (950, 1), (960, 1), (970, 1), (980, 1), (990, 1), (1000, 0), (1010, 1), (1020, 1), (1030, 1), (1040, 0), (1050, 1), (1060, 1), (1070, 0), (1080, 1), (1090, 1), (1100, 1), (1110, 1), (1120, 1), (1130, 0), (1140, 1), (1150, 1), (1160, 1), (1170, 1), (1180, 0), (1190, 0), (1200, 1), (1210, 0), (1220, 0), (1230, 0), (1240, 1), (1250, 0), (1260, 1), (1270, 1), (1280, 0), (1290, 0), (1300, 1), (1310, 1), (1320, 1), (1330, 1), (1340, 1), (1350, 0), (1360, 1), (1370, 1), (1380, 1), (1390, 1), (1400, 0), (1410, 0), (1420, 1), (1430, 0), (1440, 1), (1450, 1), (1460, 1), (1470, 1), (1480, 1), (1490, 1), (1500, 1), (1510, 1), (1520, 0), (1530, 1), (1540, 1), (1550, 1), (1560, 0), (1570, 0), (1580, 0), (1590, 1), (1600, 1), (1610, 1), (1620, 1), (1630, 1), (1640, 1), (1650, 0), (1660, 0), (1670, 0), (1680, 1), (1690, 0), (1700, 0), (1710, 1), (1720, 1), (1730, 0), (1740, 1), (1750, 0), (1760, 0), (1770, 1), (1780, 1), (1790, 0), (1800, 1), (1810, 1), (1820, 1), (1830, 0), (1840, 1), (1850, 0), (1860, 1), (1870, 1), (1880, 1), (1890, 1), (1900, 1), (1910, 1), (1920, 1), (1930, 1), (1940, 1), (1950, 1), (1960, 1), (1970, 1), (1980, 0), (1990, 1), (2000, 1), (2010, 0), (2020, 0), (2030, 1), (2040, 1), (2050, 1)]
VWEB0 WEB0 0 PWL (0n 3.3v 9.45n 3.3v 9.55n 0.0v 19.45n 0.0v 19.55n 0.0v 29.45n 0.0v 29.55n 0.0v 39.45n 0.0v 39.55n 3.3v 49.45n 3.3v 49.55n 3.3v 59.45n 3.3v 59.55n 3.3v 69.45n 3.3v 69.55n 3.3v 79.45n 3.3v 79.55n 3.3v 89.45n 3.3v 89.55n 3.3v 99.45n 3.3v 99.55n 3.3v 109.45n 3.3v 109.55n 3.3v 119.45n 3.3v 119.55n 3.3v 129.45n 3.3v 129.55n 3.3v 139.45n 3.3v 139.55n 3.3v 149.45n 3.3v 149.55n 3.3v 159.45n 3.3v 159.55n 3.3v 169.45n 3.3v 169.55n 0.0v 179.45n 0.0v 179.55n 0.0v 189.45n 0.0v 189.55n 0.0v 199.45n 0.0v 199.55n 0.0v 209.45n 0.0v 209.55n 3.3v 219.45n 3.3v 219.55n 3.3v 229.45n 3.3v 229.55n 3.3v 239.45n 3.3v 239.55n 0.0v 249.45n 0.0v 249.55n 3.3v 259.45n 3.3v 259.55n 3.3v 269.45n 3.3v 269.55n 3.3v 279.45n 3.3v 279.55n 3.3v 289.45n 3.3v 289.55n 3.3v 299.45n 3.3v 299.55n 3.3v 309.45n 3.3v 309.55n 3.3v 319.45n 3.3v 319.55n 3.3v 329.45n 3.3v 329.55n 0.0v 339.45n 0.0v 339.55n 3.3v 349.45n 3.3v 349.55n 0.0v 359.45n 0.0v 359.55n 3.3v 369.45n 3.3v 369.55n 0.0v 379.45n 0.0v 379.55n 3.3v 389.45n 3.3v 389.55n 3.3v 399.45n 3.3v 399.55n 3.3v 409.45n 3.3v 409.55n 3.3v 419.45n 3.3v 419.55n 3.3v 429.45n 3.3v 429.55n 3.3v 439.45n 3.3v 439.55n 0.0v 449.45n 0.0v 449.55n 3.3v 459.45n 3.3v 459.55n 0.0v 469.45n 0.0v 469.55n 3.3v 479.45n 3.3v 479.55n 3.3v 489.45n 3.3v 489.55n 3.3v 499.45n 3.3v 499.55n 3.3v 509.45n 3.3v 509.55n 0.0v 519.45n 0.0v 519.55n 3.3v 529.45n 3.3v 529.55n 3.3v 539.45n 3.3v 539.55n 3.3v 549.45n 3.3v 549.55n 3.3v 559.45n 3.3v 559.55n 0.0v 569.45n 0.0v 569.55n 3.3v 579.45n 3.3v 579.55n 3.3v 589.45n 3.3v 589.55n 3.3v 599.45n 3.3v 599.55n 3.3v 609.45n 3.3v 609.55n 0.0v 619.45n 0.0v 619.55n 0.0v 629.45n 0.0v 629.55n 3.3v 639.45n 3.3v 639.55n 3.3v 649.45n 3.3v 649.55n 0.0v 659.45n 0.0v 659.55n 3.3v 669.45n 3.3v 669.55n 3.3v 679.45n 3.3v 679.55n 0.0v 689.45n 0.0v 689.55n 3.3v 699.45n 3.3v 699.55n 3.3v 709.45n 3.3v 709.55n 3.3v 719.45n 3.3v 719.55n 3.3v 729.45n 3.3v 729.55n 3.3v 739.45n 3.3v 739.55n 3.3v 749.45n 3.3v 749.55n 0.0v 759.45n 0.0v 759.55n 0.0v 769.45n 0.0v 769.55n 0.0v 779.45n 0.0v 779.55n 0.0v 789.45n 0.0v 789.55n 3.3v 799.45n 3.3v 799.55n 0.0v 809.45n 0.0v 809.55n 3.3v 819.45n 3.3v 819.55n 3.3v 829.45n 3.3v 829.55n 3.3v 839.45n 3.3v 839.55n 0.0v 849.45n 0.0v 849.55n 3.3v 859.45n 3.3v 859.55n 3.3v 869.45n 3.3v 869.55n 0.0v 879.45n 0.0v 879.55n 3.3v 889.45n 3.3v 889.55n 0.0v 899.45n 0.0v 899.55n 0.0v 909.45n 0.0v 909.55n 3.3v 919.45n 3.3v 919.55n 3.3v 929.45n 3.3v 929.55n 3.3v 939.45n 3.3v 939.55n 3.3v 949.45n 3.3v 949.55n 3.3v 959.45n 3.3v 959.55n 3.3v 969.45n 3.3v 969.55n 3.3v 979.45n 3.3v 979.55n 3.3v 989.45n 3.3v 989.55n 3.3v 999.45n 3.3v 999.55n 0.0v 1009.45n 0.0v 1009.55n 3.3v 1019.45n 3.3v 1019.55n 3.3v 1029.45n 3.3v 1029.55n 3.3v 1039.45n 3.3v 1039.55n 0.0v 1049.45n 0.0v 1049.55n 3.3v 1059.45n 3.3v 1059.55n 3.3v 1069.45n 3.3v 1069.55n 0.0v 1079.45n 0.0v 1079.55n 3.3v 1089.45n 3.3v 1089.55n 3.3v 1099.45n 3.3v 1099.55n 3.3v 1109.45n 3.3v 1109.55n 3.3v 1119.45n 3.3v 1119.55n 3.3v 1129.45n 3.3v 1129.55n 0.0v 1139.45n 0.0v 1139.55n 3.3v 1149.45n 3.3v 1149.55n 3.3v 1159.45n 3.3v 1159.55n 3.3v 1169.45n 3.3v 1169.55n 3.3v 1179.45n 3.3v 1179.55n 0.0v 1189.45n 0.0v 1189.55n 0.0v 1199.45n 0.0v 1199.55n 3.3v 1209.45n 3.3v 1209.55n 0.0v 1219.45n 0.0v 1219.55n 0.0v 1229.45n 0.0v 1229.55n 0.0v 1239.45n 0.0v 1239.55n 3.3v 1249.45n 3.3v 1249.55n 0.0v 1259.45n 0.0v 1259.55n 3.3v 1269.45n 3.3v 1269.55n 3.3v 1279.45n 3.3v 1279.55n 0.0v 1289.45n 0.0v 1289.55n 0.0v 1299.45n 0.0v 1299.55n 3.3v 1309.45n 3.3v 1309.55n 3.3v 1319.45n 3.3v 1319.55n 3.3v 1329.45n 3.3v 1329.55n 3.3v 1339.45n 3.3v 1339.55n 3.3v 1349.45n 3.3v 1349.55n 0.0v 1359.45n 0.0v 1359.55n 3.3v 1369.45n 3.3v 1369.55n 3.3v 1379.45n 3.3v 1379.55n 3.3v 1389.45n 3.3v 1389.55n 3.3v 1399.45n 3.3v 1399.55n 0.0v 1409.45n 0.0v 1409.55n 0.0v 1419.45n 0.0v 1419.55n 3.3v 1429.45n 3.3v 1429.55n 0.0v 1439.45n 0.0v 1439.55n 3.3v 1449.45n 3.3v 1449.55n 3.3v 1459.45n 3.3v 1459.55n 3.3v 1469.45n 3.3v 1469.55n 3.3v 1479.45n 3.3v 1479.55n 3.3v 1489.45n 3.3v 1489.55n 3.3v 1499.45n 3.3v 1499.55n 3.3v 1509.45n 3.3v 1509.55n 3.3v 1519.45n 3.3v 1519.55n 0.0v 1529.45n 0.0v 1529.55n 3.3v 1539.45n 3.3v 1539.55n 3.3v 1549.45n 3.3v 1549.55n 3.3v 1559.45n 3.3v 1559.55n 0.0v 1569.45n 0.0v 1569.55n 0.0v 1579.45n 0.0v 1579.55n 0.0v 1589.45n 0.0v 1589.55n 3.3v 1599.45n 3.3v 1599.55n 3.3v 1609.45n 3.3v 1609.55n 3.3v 1619.45n 3.3v 1619.55n 3.3v 1629.45n 3.3v 1629.55n 3.3v 1639.45n 3.3v 1639.55n 3.3v 1649.45n 3.3v 1649.55n 0.0v 1659.45n 0.0v 1659.55n 0.0v 1669.45n 0.0v 1669.55n 0.0v 1679.45n 0.0v 1679.55n 3.3v 1689.45n 3.3v 1689.55n 0.0v 1699.45n 0.0v 1699.55n 0.0v 1709.45n 0.0v 1709.55n 3.3v 1719.45n 3.3v 1719.55n 3.3v 1729.45n 3.3v 1729.55n 0.0v 1739.45n 0.0v 1739.55n 3.3v 1749.45n 3.3v 1749.55n 0.0v 1759.45n 0.0v 1759.55n 0.0v 1769.45n 0.0v 1769.55n 3.3v 1779.45n 3.3v 1779.55n 3.3v 1789.45n 3.3v 1789.55n 0.0v 1799.45n 0.0v 1799.55n 3.3v 1809.45n 3.3v 1809.55n 3.3v 1819.45n 3.3v 1819.55n 3.3v 1829.45n 3.3v 1829.55n 0.0v 1839.45n 0.0v 1839.55n 3.3v 1849.45n 3.3v 1849.55n 0.0v 1859.45n 0.0v 1859.55n 3.3v 1869.45n 3.3v 1869.55n 3.3v 1879.45n 3.3v 1879.55n 3.3v 1889.45n 3.3v 1889.55n 3.3v 1899.45n 3.3v 1899.55n 3.3v 1909.45n 3.3v 1909.55n 3.3v 1919.45n 3.3v 1919.55n 3.3v 1929.45n 3.3v 1929.55n 3.3v 1939.45n 3.3v 1939.55n 3.3v 1949.45n 3.3v 1949.55n 3.3v 1959.45n 3.3v 1959.55n 3.3v 1969.45n 3.3v 1969.55n 3.3v 1979.45n 3.3v 1979.55n 0.0v 1989.45n 0.0v 1989.55n 3.3v 1999.45n 3.3v 1999.55n 3.3v 2009.45n 3.3v 2009.55n 0.0v 2019.45n 0.0v 2019.55n 0.0v 2029.45n 0.0v 2029.55n 3.3v 2039.45n 3.3v 2039.55n 3.3v 2049.45n 3.3v 2049.55n 3.3v )
* PULSE: period=10
Vclk0 clk0 0 PULSE (0 3.3 9.95n 0.1n 0.1n 4.9n 10n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 3.3 time = 50
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=50.05n

* CHECK dout0_1 Vdout0_1ck4 = 0 time = 50
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=50.05n

* CHECK dout0_2 Vdout0_2ck4 = 3.3 time = 50
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=50.05n

* CHECK dout0_3 Vdout0_3ck4 = 3.3 time = 50
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=50.05n

* CHECK dout0_4 Vdout0_4ck4 = 3.3 time = 50
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=50.05n

* CHECK dout0_5 Vdout0_5ck4 = 3.3 time = 50
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=50.05n

* CHECK dout0_6 Vdout0_6ck4 = 3.3 time = 50
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=50.05n

* CHECK dout0_7 Vdout0_7ck4 = 3.3 time = 50
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=50.05n

* CHECK dout0_0 Vdout0_0ck5 = 0 time = 60
.meas tran vdout0_0ck5 FIND v(dout0_0) AT=60.05n

* CHECK dout0_1 Vdout0_1ck5 = 3.3 time = 60
.meas tran vdout0_1ck5 FIND v(dout0_1) AT=60.05n

* CHECK dout0_2 Vdout0_2ck5 = 0 time = 60
.meas tran vdout0_2ck5 FIND v(dout0_2) AT=60.05n

* CHECK dout0_3 Vdout0_3ck5 = 0 time = 60
.meas tran vdout0_3ck5 FIND v(dout0_3) AT=60.05n

* CHECK dout0_4 Vdout0_4ck5 = 0 time = 60
.meas tran vdout0_4ck5 FIND v(dout0_4) AT=60.05n

* CHECK dout0_5 Vdout0_5ck5 = 0 time = 60
.meas tran vdout0_5ck5 FIND v(dout0_5) AT=60.05n

* CHECK dout0_6 Vdout0_6ck5 = 0 time = 60
.meas tran vdout0_6ck5 FIND v(dout0_6) AT=60.05n

* CHECK dout0_7 Vdout0_7ck5 = 3.3 time = 60
.meas tran vdout0_7ck5 FIND v(dout0_7) AT=60.05n

* CHECK dout0_0 Vdout0_0ck6 = 0 time = 70
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=70.05n

* CHECK dout0_1 Vdout0_1ck6 = 3.3 time = 70
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=70.05n

* CHECK dout0_2 Vdout0_2ck6 = 0 time = 70
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=70.05n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 70
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=70.05n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 70
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=70.05n

* CHECK dout0_5 Vdout0_5ck6 = 0 time = 70
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=70.05n

* CHECK dout0_6 Vdout0_6ck6 = 0 time = 70
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=70.05n

* CHECK dout0_7 Vdout0_7ck6 = 3.3 time = 70
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=70.05n

* CHECK dout0_0 Vdout0_0ck8 = 3.3 time = 90
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=90.05n

* CHECK dout0_1 Vdout0_1ck8 = 0 time = 90
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=90.05n

* CHECK dout0_2 Vdout0_2ck8 = 3.3 time = 90
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=90.05n

* CHECK dout0_3 Vdout0_3ck8 = 3.3 time = 90
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=90.05n

* CHECK dout0_4 Vdout0_4ck8 = 3.3 time = 90
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=90.05n

* CHECK dout0_5 Vdout0_5ck8 = 3.3 time = 90
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=90.05n

* CHECK dout0_6 Vdout0_6ck8 = 3.3 time = 90
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=90.05n

* CHECK dout0_7 Vdout0_7ck8 = 3.3 time = 90
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=90.05n

* CHECK dout0_0 Vdout0_0ck9 = 3.3 time = 100
.meas tran vdout0_0ck9 FIND v(dout0_0) AT=100.05n

* CHECK dout0_1 Vdout0_1ck9 = 0 time = 100
.meas tran vdout0_1ck9 FIND v(dout0_1) AT=100.05n

* CHECK dout0_2 Vdout0_2ck9 = 3.3 time = 100
.meas tran vdout0_2ck9 FIND v(dout0_2) AT=100.05n

* CHECK dout0_3 Vdout0_3ck9 = 3.3 time = 100
.meas tran vdout0_3ck9 FIND v(dout0_3) AT=100.05n

* CHECK dout0_4 Vdout0_4ck9 = 3.3 time = 100
.meas tran vdout0_4ck9 FIND v(dout0_4) AT=100.05n

* CHECK dout0_5 Vdout0_5ck9 = 3.3 time = 100
.meas tran vdout0_5ck9 FIND v(dout0_5) AT=100.05n

* CHECK dout0_6 Vdout0_6ck9 = 3.3 time = 100
.meas tran vdout0_6ck9 FIND v(dout0_6) AT=100.05n

* CHECK dout0_7 Vdout0_7ck9 = 3.3 time = 100
.meas tran vdout0_7ck9 FIND v(dout0_7) AT=100.05n

* CHECK dout0_0 Vdout0_0ck10 = 0 time = 110
.meas tran vdout0_0ck10 FIND v(dout0_0) AT=110.05n

* CHECK dout0_1 Vdout0_1ck10 = 3.3 time = 110
.meas tran vdout0_1ck10 FIND v(dout0_1) AT=110.05n

* CHECK dout0_2 Vdout0_2ck10 = 0 time = 110
.meas tran vdout0_2ck10 FIND v(dout0_2) AT=110.05n

* CHECK dout0_3 Vdout0_3ck10 = 0 time = 110
.meas tran vdout0_3ck10 FIND v(dout0_3) AT=110.05n

* CHECK dout0_4 Vdout0_4ck10 = 0 time = 110
.meas tran vdout0_4ck10 FIND v(dout0_4) AT=110.05n

* CHECK dout0_5 Vdout0_5ck10 = 0 time = 110
.meas tran vdout0_5ck10 FIND v(dout0_5) AT=110.05n

* CHECK dout0_6 Vdout0_6ck10 = 0 time = 110
.meas tran vdout0_6ck10 FIND v(dout0_6) AT=110.05n

* CHECK dout0_7 Vdout0_7ck10 = 3.3 time = 110
.meas tran vdout0_7ck10 FIND v(dout0_7) AT=110.05n

* CHECK dout0_0 Vdout0_0ck12 = 3.3 time = 130
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=130.05n

* CHECK dout0_1 Vdout0_1ck12 = 0 time = 130
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=130.05n

* CHECK dout0_2 Vdout0_2ck12 = 3.3 time = 130
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=130.05n

* CHECK dout0_3 Vdout0_3ck12 = 3.3 time = 130
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=130.05n

* CHECK dout0_4 Vdout0_4ck12 = 3.3 time = 130
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=130.05n

* CHECK dout0_5 Vdout0_5ck12 = 3.3 time = 130
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=130.05n

* CHECK dout0_6 Vdout0_6ck12 = 3.3 time = 130
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=130.05n

* CHECK dout0_7 Vdout0_7ck12 = 3.3 time = 130
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=130.05n

* CHECK dout0_0 Vdout0_0ck13 = 3.3 time = 140
.meas tran vdout0_0ck13 FIND v(dout0_0) AT=140.05n

* CHECK dout0_1 Vdout0_1ck13 = 0 time = 140
.meas tran vdout0_1ck13 FIND v(dout0_1) AT=140.05n

* CHECK dout0_2 Vdout0_2ck13 = 3.3 time = 140
.meas tran vdout0_2ck13 FIND v(dout0_2) AT=140.05n

* CHECK dout0_3 Vdout0_3ck13 = 3.3 time = 140
.meas tran vdout0_3ck13 FIND v(dout0_3) AT=140.05n

* CHECK dout0_4 Vdout0_4ck13 = 3.3 time = 140
.meas tran vdout0_4ck13 FIND v(dout0_4) AT=140.05n

* CHECK dout0_5 Vdout0_5ck13 = 3.3 time = 140
.meas tran vdout0_5ck13 FIND v(dout0_5) AT=140.05n

* CHECK dout0_6 Vdout0_6ck13 = 3.3 time = 140
.meas tran vdout0_6ck13 FIND v(dout0_6) AT=140.05n

* CHECK dout0_7 Vdout0_7ck13 = 3.3 time = 140
.meas tran vdout0_7ck13 FIND v(dout0_7) AT=140.05n

* CHECK dout0_0 Vdout0_0ck14 = 3.3 time = 150
.meas tran vdout0_0ck14 FIND v(dout0_0) AT=150.05n

* CHECK dout0_1 Vdout0_1ck14 = 0 time = 150
.meas tran vdout0_1ck14 FIND v(dout0_1) AT=150.05n

* CHECK dout0_2 Vdout0_2ck14 = 3.3 time = 150
.meas tran vdout0_2ck14 FIND v(dout0_2) AT=150.05n

* CHECK dout0_3 Vdout0_3ck14 = 3.3 time = 150
.meas tran vdout0_3ck14 FIND v(dout0_3) AT=150.05n

* CHECK dout0_4 Vdout0_4ck14 = 3.3 time = 150
.meas tran vdout0_4ck14 FIND v(dout0_4) AT=150.05n

* CHECK dout0_5 Vdout0_5ck14 = 3.3 time = 150
.meas tran vdout0_5ck14 FIND v(dout0_5) AT=150.05n

* CHECK dout0_6 Vdout0_6ck14 = 3.3 time = 150
.meas tran vdout0_6ck14 FIND v(dout0_6) AT=150.05n

* CHECK dout0_7 Vdout0_7ck14 = 3.3 time = 150
.meas tran vdout0_7ck14 FIND v(dout0_7) AT=150.05n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 160
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=160.05n

* CHECK dout0_1 Vdout0_1ck15 = 3.3 time = 160
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=160.05n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 160
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=160.05n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 160
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=160.05n

* CHECK dout0_4 Vdout0_4ck15 = 0 time = 160
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=160.05n

* CHECK dout0_5 Vdout0_5ck15 = 0 time = 160
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=160.05n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 160
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=160.05n

* CHECK dout0_7 Vdout0_7ck15 = 3.3 time = 160
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=160.05n

* CHECK dout0_0 Vdout0_0ck16 = 0 time = 170
.meas tran vdout0_0ck16 FIND v(dout0_0) AT=170.05n

* CHECK dout0_1 Vdout0_1ck16 = 3.3 time = 170
.meas tran vdout0_1ck16 FIND v(dout0_1) AT=170.05n

* CHECK dout0_2 Vdout0_2ck16 = 0 time = 170
.meas tran vdout0_2ck16 FIND v(dout0_2) AT=170.05n

* CHECK dout0_3 Vdout0_3ck16 = 0 time = 170
.meas tran vdout0_3ck16 FIND v(dout0_3) AT=170.05n

* CHECK dout0_4 Vdout0_4ck16 = 0 time = 170
.meas tran vdout0_4ck16 FIND v(dout0_4) AT=170.05n

* CHECK dout0_5 Vdout0_5ck16 = 0 time = 170
.meas tran vdout0_5ck16 FIND v(dout0_5) AT=170.05n

* CHECK dout0_6 Vdout0_6ck16 = 0 time = 170
.meas tran vdout0_6ck16 FIND v(dout0_6) AT=170.05n

* CHECK dout0_7 Vdout0_7ck16 = 3.3 time = 170
.meas tran vdout0_7ck16 FIND v(dout0_7) AT=170.05n

* CHECK dout0_0 Vdout0_0ck23 = 0 time = 240
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=240.05n

* CHECK dout0_1 Vdout0_1ck23 = 3.3 time = 240
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=240.05n

* CHECK dout0_2 Vdout0_2ck23 = 3.3 time = 240
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=240.05n

* CHECK dout0_3 Vdout0_3ck23 = 0 time = 240
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=240.05n

* CHECK dout0_4 Vdout0_4ck23 = 0 time = 240
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=240.05n

* CHECK dout0_5 Vdout0_5ck23 = 3.3 time = 240
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=240.05n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 240
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=240.05n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 240
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=240.05n

* CHECK dout0_0 Vdout0_0ck26 = 0 time = 270
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=270.05n

* CHECK dout0_1 Vdout0_1ck26 = 3.3 time = 270
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=270.05n

* CHECK dout0_2 Vdout0_2ck26 = 3.3 time = 270
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=270.05n

* CHECK dout0_3 Vdout0_3ck26 = 0 time = 270
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=270.05n

* CHECK dout0_4 Vdout0_4ck26 = 0 time = 270
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=270.05n

* CHECK dout0_5 Vdout0_5ck26 = 3.3 time = 270
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=270.05n

* CHECK dout0_6 Vdout0_6ck26 = 0 time = 270
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=270.05n

* CHECK dout0_7 Vdout0_7ck26 = 0 time = 270
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=270.05n

* CHECK dout0_0 Vdout0_0ck29 = 0 time = 300
.meas tran vdout0_0ck29 FIND v(dout0_0) AT=300.05n

* CHECK dout0_1 Vdout0_1ck29 = 3.3 time = 300
.meas tran vdout0_1ck29 FIND v(dout0_1) AT=300.05n

* CHECK dout0_2 Vdout0_2ck29 = 3.3 time = 300
.meas tran vdout0_2ck29 FIND v(dout0_2) AT=300.05n

* CHECK dout0_3 Vdout0_3ck29 = 0 time = 300
.meas tran vdout0_3ck29 FIND v(dout0_3) AT=300.05n

* CHECK dout0_4 Vdout0_4ck29 = 0 time = 300
.meas tran vdout0_4ck29 FIND v(dout0_4) AT=300.05n

* CHECK dout0_5 Vdout0_5ck29 = 3.3 time = 300
.meas tran vdout0_5ck29 FIND v(dout0_5) AT=300.05n

* CHECK dout0_6 Vdout0_6ck29 = 0 time = 300
.meas tran vdout0_6ck29 FIND v(dout0_6) AT=300.05n

* CHECK dout0_7 Vdout0_7ck29 = 0 time = 300
.meas tran vdout0_7ck29 FIND v(dout0_7) AT=300.05n

* CHECK dout0_0 Vdout0_0ck32 = 3.3 time = 330
.meas tran vdout0_0ck32 FIND v(dout0_0) AT=330.05n

* CHECK dout0_1 Vdout0_1ck32 = 0 time = 330
.meas tran vdout0_1ck32 FIND v(dout0_1) AT=330.05n

* CHECK dout0_2 Vdout0_2ck32 = 0 time = 330
.meas tran vdout0_2ck32 FIND v(dout0_2) AT=330.05n

* CHECK dout0_3 Vdout0_3ck32 = 3.3 time = 330
.meas tran vdout0_3ck32 FIND v(dout0_3) AT=330.05n

* CHECK dout0_4 Vdout0_4ck32 = 3.3 time = 330
.meas tran vdout0_4ck32 FIND v(dout0_4) AT=330.05n

* CHECK dout0_5 Vdout0_5ck32 = 3.3 time = 330
.meas tran vdout0_5ck32 FIND v(dout0_5) AT=330.05n

* CHECK dout0_6 Vdout0_6ck32 = 3.3 time = 330
.meas tran vdout0_6ck32 FIND v(dout0_6) AT=330.05n

* CHECK dout0_7 Vdout0_7ck32 = 3.3 time = 330
.meas tran vdout0_7ck32 FIND v(dout0_7) AT=330.05n

* CHECK dout0_0 Vdout0_0ck36 = 3.3 time = 370
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=370.05n

* CHECK dout0_1 Vdout0_1ck36 = 3.3 time = 370
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=370.05n

* CHECK dout0_2 Vdout0_2ck36 = 3.3 time = 370
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=370.05n

* CHECK dout0_3 Vdout0_3ck36 = 0 time = 370
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=370.05n

* CHECK dout0_4 Vdout0_4ck36 = 3.3 time = 370
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=370.05n

* CHECK dout0_5 Vdout0_5ck36 = 0 time = 370
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=370.05n

* CHECK dout0_6 Vdout0_6ck36 = 3.3 time = 370
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=370.05n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 370
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=370.05n

* CHECK dout0_0 Vdout0_0ck38 = 3.3 time = 390
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=390.05n

* CHECK dout0_1 Vdout0_1ck38 = 0 time = 390
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=390.05n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 390
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=390.05n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 390
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=390.05n

* CHECK dout0_4 Vdout0_4ck38 = 0 time = 390
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=390.05n

* CHECK dout0_5 Vdout0_5ck38 = 3.3 time = 390
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=390.05n

* CHECK dout0_6 Vdout0_6ck38 = 3.3 time = 390
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=390.05n

* CHECK dout0_7 Vdout0_7ck38 = 3.3 time = 390
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=390.05n

* CHECK dout0_0 Vdout0_0ck39 = 3.3 time = 400
.meas tran vdout0_0ck39 FIND v(dout0_0) AT=400.05n

* CHECK dout0_1 Vdout0_1ck39 = 0 time = 400
.meas tran vdout0_1ck39 FIND v(dout0_1) AT=400.05n

* CHECK dout0_2 Vdout0_2ck39 = 0 time = 400
.meas tran vdout0_2ck39 FIND v(dout0_2) AT=400.05n

* CHECK dout0_3 Vdout0_3ck39 = 0 time = 400
.meas tran vdout0_3ck39 FIND v(dout0_3) AT=400.05n

* CHECK dout0_4 Vdout0_4ck39 = 0 time = 400
.meas tran vdout0_4ck39 FIND v(dout0_4) AT=400.05n

* CHECK dout0_5 Vdout0_5ck39 = 3.3 time = 400
.meas tran vdout0_5ck39 FIND v(dout0_5) AT=400.05n

* CHECK dout0_6 Vdout0_6ck39 = 3.3 time = 400
.meas tran vdout0_6ck39 FIND v(dout0_6) AT=400.05n

* CHECK dout0_7 Vdout0_7ck39 = 3.3 time = 400
.meas tran vdout0_7ck39 FIND v(dout0_7) AT=400.05n

* CHECK dout0_0 Vdout0_0ck40 = 3.3 time = 410
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=410.05n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 410
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=410.05n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 410
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=410.05n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 410
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=410.05n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 410
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=410.05n

* CHECK dout0_5 Vdout0_5ck40 = 3.3 time = 410
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=410.05n

* CHECK dout0_6 Vdout0_6ck40 = 3.3 time = 410
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=410.05n

* CHECK dout0_7 Vdout0_7ck40 = 3.3 time = 410
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=410.05n

* CHECK dout0_0 Vdout0_0ck41 = 3.3 time = 420
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=420.05n

* CHECK dout0_1 Vdout0_1ck41 = 3.3 time = 420
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=420.05n

* CHECK dout0_2 Vdout0_2ck41 = 3.3 time = 420
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=420.05n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 420
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=420.05n

* CHECK dout0_4 Vdout0_4ck41 = 3.3 time = 420
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=420.05n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 420
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=420.05n

* CHECK dout0_6 Vdout0_6ck41 = 3.3 time = 420
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=420.05n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 420
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=420.05n

* CHECK dout0_0 Vdout0_0ck42 = 3.3 time = 430
.meas tran vdout0_0ck42 FIND v(dout0_0) AT=430.05n

* CHECK dout0_1 Vdout0_1ck42 = 3.3 time = 430
.meas tran vdout0_1ck42 FIND v(dout0_1) AT=430.05n

* CHECK dout0_2 Vdout0_2ck42 = 3.3 time = 430
.meas tran vdout0_2ck42 FIND v(dout0_2) AT=430.05n

* CHECK dout0_3 Vdout0_3ck42 = 0 time = 430
.meas tran vdout0_3ck42 FIND v(dout0_3) AT=430.05n

* CHECK dout0_4 Vdout0_4ck42 = 3.3 time = 430
.meas tran vdout0_4ck42 FIND v(dout0_4) AT=430.05n

* CHECK dout0_5 Vdout0_5ck42 = 0 time = 430
.meas tran vdout0_5ck42 FIND v(dout0_5) AT=430.05n

* CHECK dout0_6 Vdout0_6ck42 = 3.3 time = 430
.meas tran vdout0_6ck42 FIND v(dout0_6) AT=430.05n

* CHECK dout0_7 Vdout0_7ck42 = 0 time = 430
.meas tran vdout0_7ck42 FIND v(dout0_7) AT=430.05n

* CHECK dout0_0 Vdout0_0ck43 = 3.3 time = 440
.meas tran vdout0_0ck43 FIND v(dout0_0) AT=440.05n

* CHECK dout0_1 Vdout0_1ck43 = 0 time = 440
.meas tran vdout0_1ck43 FIND v(dout0_1) AT=440.05n

* CHECK dout0_2 Vdout0_2ck43 = 0 time = 440
.meas tran vdout0_2ck43 FIND v(dout0_2) AT=440.05n

* CHECK dout0_3 Vdout0_3ck43 = 0 time = 440
.meas tran vdout0_3ck43 FIND v(dout0_3) AT=440.05n

* CHECK dout0_4 Vdout0_4ck43 = 0 time = 440
.meas tran vdout0_4ck43 FIND v(dout0_4) AT=440.05n

* CHECK dout0_5 Vdout0_5ck43 = 3.3 time = 440
.meas tran vdout0_5ck43 FIND v(dout0_5) AT=440.05n

* CHECK dout0_6 Vdout0_6ck43 = 3.3 time = 440
.meas tran vdout0_6ck43 FIND v(dout0_6) AT=440.05n

* CHECK dout0_7 Vdout0_7ck43 = 3.3 time = 440
.meas tran vdout0_7ck43 FIND v(dout0_7) AT=440.05n

* CHECK dout0_0 Vdout0_0ck45 = 0 time = 460
.meas tran vdout0_0ck45 FIND v(dout0_0) AT=460.05n

* CHECK dout0_1 Vdout0_1ck45 = 3.3 time = 460
.meas tran vdout0_1ck45 FIND v(dout0_1) AT=460.05n

* CHECK dout0_2 Vdout0_2ck45 = 0 time = 460
.meas tran vdout0_2ck45 FIND v(dout0_2) AT=460.05n

* CHECK dout0_3 Vdout0_3ck45 = 3.3 time = 460
.meas tran vdout0_3ck45 FIND v(dout0_3) AT=460.05n

* CHECK dout0_4 Vdout0_4ck45 = 3.3 time = 460
.meas tran vdout0_4ck45 FIND v(dout0_4) AT=460.05n

* CHECK dout0_5 Vdout0_5ck45 = 3.3 time = 460
.meas tran vdout0_5ck45 FIND v(dout0_5) AT=460.05n

* CHECK dout0_6 Vdout0_6ck45 = 3.3 time = 460
.meas tran vdout0_6ck45 FIND v(dout0_6) AT=460.05n

* CHECK dout0_7 Vdout0_7ck45 = 0 time = 460
.meas tran vdout0_7ck45 FIND v(dout0_7) AT=460.05n

* CHECK dout0_0 Vdout0_0ck47 = 0 time = 480
.meas tran vdout0_0ck47 FIND v(dout0_0) AT=480.05n

* CHECK dout0_1 Vdout0_1ck47 = 0 time = 480
.meas tran vdout0_1ck47 FIND v(dout0_1) AT=480.05n

* CHECK dout0_2 Vdout0_2ck47 = 3.3 time = 480
.meas tran vdout0_2ck47 FIND v(dout0_2) AT=480.05n

* CHECK dout0_3 Vdout0_3ck47 = 3.3 time = 480
.meas tran vdout0_3ck47 FIND v(dout0_3) AT=480.05n

* CHECK dout0_4 Vdout0_4ck47 = 0 time = 480
.meas tran vdout0_4ck47 FIND v(dout0_4) AT=480.05n

* CHECK dout0_5 Vdout0_5ck47 = 3.3 time = 480
.meas tran vdout0_5ck47 FIND v(dout0_5) AT=480.05n

* CHECK dout0_6 Vdout0_6ck47 = 3.3 time = 480
.meas tran vdout0_6ck47 FIND v(dout0_6) AT=480.05n

* CHECK dout0_7 Vdout0_7ck47 = 3.3 time = 480
.meas tran vdout0_7ck47 FIND v(dout0_7) AT=480.05n

* CHECK dout0_0 Vdout0_0ck49 = 3.3 time = 500
.meas tran vdout0_0ck49 FIND v(dout0_0) AT=500.05n

* CHECK dout0_1 Vdout0_1ck49 = 3.3 time = 500
.meas tran vdout0_1ck49 FIND v(dout0_1) AT=500.05n

* CHECK dout0_2 Vdout0_2ck49 = 3.3 time = 500
.meas tran vdout0_2ck49 FIND v(dout0_2) AT=500.05n

* CHECK dout0_3 Vdout0_3ck49 = 0 time = 500
.meas tran vdout0_3ck49 FIND v(dout0_3) AT=500.05n

* CHECK dout0_4 Vdout0_4ck49 = 3.3 time = 500
.meas tran vdout0_4ck49 FIND v(dout0_4) AT=500.05n

* CHECK dout0_5 Vdout0_5ck49 = 0 time = 500
.meas tran vdout0_5ck49 FIND v(dout0_5) AT=500.05n

* CHECK dout0_6 Vdout0_6ck49 = 3.3 time = 500
.meas tran vdout0_6ck49 FIND v(dout0_6) AT=500.05n

* CHECK dout0_7 Vdout0_7ck49 = 0 time = 500
.meas tran vdout0_7ck49 FIND v(dout0_7) AT=500.05n

* CHECK dout0_0 Vdout0_0ck52 = 3.3 time = 530
.meas tran vdout0_0ck52 FIND v(dout0_0) AT=530.05n

* CHECK dout0_1 Vdout0_1ck52 = 3.3 time = 530
.meas tran vdout0_1ck52 FIND v(dout0_1) AT=530.05n

* CHECK dout0_2 Vdout0_2ck52 = 0 time = 530
.meas tran vdout0_2ck52 FIND v(dout0_2) AT=530.05n

* CHECK dout0_3 Vdout0_3ck52 = 0 time = 530
.meas tran vdout0_3ck52 FIND v(dout0_3) AT=530.05n

* CHECK dout0_4 Vdout0_4ck52 = 3.3 time = 530
.meas tran vdout0_4ck52 FIND v(dout0_4) AT=530.05n

* CHECK dout0_5 Vdout0_5ck52 = 3.3 time = 530
.meas tran vdout0_5ck52 FIND v(dout0_5) AT=530.05n

* CHECK dout0_6 Vdout0_6ck52 = 3.3 time = 530
.meas tran vdout0_6ck52 FIND v(dout0_6) AT=530.05n

* CHECK dout0_7 Vdout0_7ck52 = 3.3 time = 530
.meas tran vdout0_7ck52 FIND v(dout0_7) AT=530.05n

* CHECK dout0_0 Vdout0_0ck53 = 3.3 time = 540
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=540.05n

* CHECK dout0_1 Vdout0_1ck53 = 3.3 time = 540
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=540.05n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 540
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=540.05n

* CHECK dout0_3 Vdout0_3ck53 = 0 time = 540
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=540.05n

* CHECK dout0_4 Vdout0_4ck53 = 3.3 time = 540
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=540.05n

* CHECK dout0_5 Vdout0_5ck53 = 3.3 time = 540
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=540.05n

* CHECK dout0_6 Vdout0_6ck53 = 3.3 time = 540
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=540.05n

* CHECK dout0_7 Vdout0_7ck53 = 3.3 time = 540
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=540.05n

* CHECK dout0_0 Vdout0_0ck54 = 3.3 time = 550
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=550.05n

* CHECK dout0_1 Vdout0_1ck54 = 3.3 time = 550
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=550.05n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 550
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=550.05n

* CHECK dout0_3 Vdout0_3ck54 = 0 time = 550
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=550.05n

* CHECK dout0_4 Vdout0_4ck54 = 3.3 time = 550
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=550.05n

* CHECK dout0_5 Vdout0_5ck54 = 3.3 time = 550
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=550.05n

* CHECK dout0_6 Vdout0_6ck54 = 3.3 time = 550
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=550.05n

* CHECK dout0_7 Vdout0_7ck54 = 3.3 time = 550
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=550.05n

* CHECK dout0_0 Vdout0_0ck55 = 3.3 time = 560
.meas tran vdout0_0ck55 FIND v(dout0_0) AT=560.05n

* CHECK dout0_1 Vdout0_1ck55 = 3.3 time = 560
.meas tran vdout0_1ck55 FIND v(dout0_1) AT=560.05n

* CHECK dout0_2 Vdout0_2ck55 = 3.3 time = 560
.meas tran vdout0_2ck55 FIND v(dout0_2) AT=560.05n

* CHECK dout0_3 Vdout0_3ck55 = 0 time = 560
.meas tran vdout0_3ck55 FIND v(dout0_3) AT=560.05n

* CHECK dout0_4 Vdout0_4ck55 = 3.3 time = 560
.meas tran vdout0_4ck55 FIND v(dout0_4) AT=560.05n

* CHECK dout0_5 Vdout0_5ck55 = 0 time = 560
.meas tran vdout0_5ck55 FIND v(dout0_5) AT=560.05n

* CHECK dout0_6 Vdout0_6ck55 = 3.3 time = 560
.meas tran vdout0_6ck55 FIND v(dout0_6) AT=560.05n

* CHECK dout0_7 Vdout0_7ck55 = 0 time = 560
.meas tran vdout0_7ck55 FIND v(dout0_7) AT=560.05n

* CHECK dout0_0 Vdout0_0ck60 = 3.3 time = 610
.meas tran vdout0_0ck60 FIND v(dout0_0) AT=610.05n

* CHECK dout0_1 Vdout0_1ck60 = 0 time = 610
.meas tran vdout0_1ck60 FIND v(dout0_1) AT=610.05n

* CHECK dout0_2 Vdout0_2ck60 = 3.3 time = 610
.meas tran vdout0_2ck60 FIND v(dout0_2) AT=610.05n

* CHECK dout0_3 Vdout0_3ck60 = 0 time = 610
.meas tran vdout0_3ck60 FIND v(dout0_3) AT=610.05n

* CHECK dout0_4 Vdout0_4ck60 = 0 time = 610
.meas tran vdout0_4ck60 FIND v(dout0_4) AT=610.05n

* CHECK dout0_5 Vdout0_5ck60 = 3.3 time = 610
.meas tran vdout0_5ck60 FIND v(dout0_5) AT=610.05n

* CHECK dout0_6 Vdout0_6ck60 = 3.3 time = 610
.meas tran vdout0_6ck60 FIND v(dout0_6) AT=610.05n

* CHECK dout0_7 Vdout0_7ck60 = 3.3 time = 610
.meas tran vdout0_7ck60 FIND v(dout0_7) AT=610.05n

* CHECK dout0_0 Vdout0_0ck64 = 3.3 time = 650
.meas tran vdout0_0ck64 FIND v(dout0_0) AT=650.05n

* CHECK dout0_1 Vdout0_1ck64 = 0 time = 650
.meas tran vdout0_1ck64 FIND v(dout0_1) AT=650.05n

* CHECK dout0_2 Vdout0_2ck64 = 3.3 time = 650
.meas tran vdout0_2ck64 FIND v(dout0_2) AT=650.05n

* CHECK dout0_3 Vdout0_3ck64 = 0 time = 650
.meas tran vdout0_3ck64 FIND v(dout0_3) AT=650.05n

* CHECK dout0_4 Vdout0_4ck64 = 3.3 time = 650
.meas tran vdout0_4ck64 FIND v(dout0_4) AT=650.05n

* CHECK dout0_5 Vdout0_5ck64 = 0 time = 650
.meas tran vdout0_5ck64 FIND v(dout0_5) AT=650.05n

* CHECK dout0_6 Vdout0_6ck64 = 3.3 time = 650
.meas tran vdout0_6ck64 FIND v(dout0_6) AT=650.05n

* CHECK dout0_7 Vdout0_7ck64 = 3.3 time = 650
.meas tran vdout0_7ck64 FIND v(dout0_7) AT=650.05n

* CHECK dout0_0 Vdout0_0ck67 = 0 time = 680
.meas tran vdout0_0ck67 FIND v(dout0_0) AT=680.05n

* CHECK dout0_1 Vdout0_1ck67 = 3.3 time = 680
.meas tran vdout0_1ck67 FIND v(dout0_1) AT=680.05n

* CHECK dout0_2 Vdout0_2ck67 = 0 time = 680
.meas tran vdout0_2ck67 FIND v(dout0_2) AT=680.05n

* CHECK dout0_3 Vdout0_3ck67 = 0 time = 680
.meas tran vdout0_3ck67 FIND v(dout0_3) AT=680.05n

* CHECK dout0_4 Vdout0_4ck67 = 3.3 time = 680
.meas tran vdout0_4ck67 FIND v(dout0_4) AT=680.05n

* CHECK dout0_5 Vdout0_5ck67 = 3.3 time = 680
.meas tran vdout0_5ck67 FIND v(dout0_5) AT=680.05n

* CHECK dout0_6 Vdout0_6ck67 = 0 time = 680
.meas tran vdout0_6ck67 FIND v(dout0_6) AT=680.05n

* CHECK dout0_7 Vdout0_7ck67 = 0 time = 680
.meas tran vdout0_7ck67 FIND v(dout0_7) AT=680.05n

* CHECK dout0_0 Vdout0_0ck71 = 0 time = 720
.meas tran vdout0_0ck71 FIND v(dout0_0) AT=720.05n

* CHECK dout0_1 Vdout0_1ck71 = 3.3 time = 720
.meas tran vdout0_1ck71 FIND v(dout0_1) AT=720.05n

* CHECK dout0_2 Vdout0_2ck71 = 0 time = 720
.meas tran vdout0_2ck71 FIND v(dout0_2) AT=720.05n

* CHECK dout0_3 Vdout0_3ck71 = 0 time = 720
.meas tran vdout0_3ck71 FIND v(dout0_3) AT=720.05n

* CHECK dout0_4 Vdout0_4ck71 = 3.3 time = 720
.meas tran vdout0_4ck71 FIND v(dout0_4) AT=720.05n

* CHECK dout0_5 Vdout0_5ck71 = 3.3 time = 720
.meas tran vdout0_5ck71 FIND v(dout0_5) AT=720.05n

* CHECK dout0_6 Vdout0_6ck71 = 0 time = 720
.meas tran vdout0_6ck71 FIND v(dout0_6) AT=720.05n

* CHECK dout0_7 Vdout0_7ck71 = 0 time = 720
.meas tran vdout0_7ck71 FIND v(dout0_7) AT=720.05n

* CHECK dout0_0 Vdout0_0ck72 = 0 time = 730
.meas tran vdout0_0ck72 FIND v(dout0_0) AT=730.05n

* CHECK dout0_1 Vdout0_1ck72 = 3.3 time = 730
.meas tran vdout0_1ck72 FIND v(dout0_1) AT=730.05n

* CHECK dout0_2 Vdout0_2ck72 = 0 time = 730
.meas tran vdout0_2ck72 FIND v(dout0_2) AT=730.05n

* CHECK dout0_3 Vdout0_3ck72 = 0 time = 730
.meas tran vdout0_3ck72 FIND v(dout0_3) AT=730.05n

* CHECK dout0_4 Vdout0_4ck72 = 3.3 time = 730
.meas tran vdout0_4ck72 FIND v(dout0_4) AT=730.05n

* CHECK dout0_5 Vdout0_5ck72 = 3.3 time = 730
.meas tran vdout0_5ck72 FIND v(dout0_5) AT=730.05n

* CHECK dout0_6 Vdout0_6ck72 = 0 time = 730
.meas tran vdout0_6ck72 FIND v(dout0_6) AT=730.05n

* CHECK dout0_7 Vdout0_7ck72 = 0 time = 730
.meas tran vdout0_7ck72 FIND v(dout0_7) AT=730.05n

* CHECK dout0_0 Vdout0_0ck79 = 3.3 time = 800
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=800.05n

* CHECK dout0_1 Vdout0_1ck79 = 3.3 time = 800
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=800.05n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 800
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=800.05n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 800
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=800.05n

* CHECK dout0_4 Vdout0_4ck79 = 0 time = 800
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=800.05n

* CHECK dout0_5 Vdout0_5ck79 = 0 time = 800
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=800.05n

* CHECK dout0_6 Vdout0_6ck79 = 0 time = 800
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=800.05n

* CHECK dout0_7 Vdout0_7ck79 = 0 time = 800
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=800.05n

* CHECK dout0_0 Vdout0_0ck83 = 3.3 time = 840
.meas tran vdout0_0ck83 FIND v(dout0_0) AT=840.05n

* CHECK dout0_1 Vdout0_1ck83 = 0 time = 840
.meas tran vdout0_1ck83 FIND v(dout0_1) AT=840.05n

* CHECK dout0_2 Vdout0_2ck83 = 3.3 time = 840
.meas tran vdout0_2ck83 FIND v(dout0_2) AT=840.05n

* CHECK dout0_3 Vdout0_3ck83 = 0 time = 840
.meas tran vdout0_3ck83 FIND v(dout0_3) AT=840.05n

* CHECK dout0_4 Vdout0_4ck83 = 0 time = 840
.meas tran vdout0_4ck83 FIND v(dout0_4) AT=840.05n

* CHECK dout0_5 Vdout0_5ck83 = 0 time = 840
.meas tran vdout0_5ck83 FIND v(dout0_5) AT=840.05n

* CHECK dout0_6 Vdout0_6ck83 = 3.3 time = 840
.meas tran vdout0_6ck83 FIND v(dout0_6) AT=840.05n

* CHECK dout0_7 Vdout0_7ck83 = 0 time = 840
.meas tran vdout0_7ck83 FIND v(dout0_7) AT=840.05n

* CHECK dout0_0 Vdout0_0ck85 = 0 time = 860
.meas tran vdout0_0ck85 FIND v(dout0_0) AT=860.05n

* CHECK dout0_1 Vdout0_1ck85 = 0 time = 860
.meas tran vdout0_1ck85 FIND v(dout0_1) AT=860.05n

* CHECK dout0_2 Vdout0_2ck85 = 0 time = 860
.meas tran vdout0_2ck85 FIND v(dout0_2) AT=860.05n

* CHECK dout0_3 Vdout0_3ck85 = 3.3 time = 860
.meas tran vdout0_3ck85 FIND v(dout0_3) AT=860.05n

* CHECK dout0_4 Vdout0_4ck85 = 3.3 time = 860
.meas tran vdout0_4ck85 FIND v(dout0_4) AT=860.05n

* CHECK dout0_5 Vdout0_5ck85 = 0 time = 860
.meas tran vdout0_5ck85 FIND v(dout0_5) AT=860.05n

* CHECK dout0_6 Vdout0_6ck85 = 3.3 time = 860
.meas tran vdout0_6ck85 FIND v(dout0_6) AT=860.05n

* CHECK dout0_7 Vdout0_7ck85 = 0 time = 860
.meas tran vdout0_7ck85 FIND v(dout0_7) AT=860.05n

* CHECK dout0_0 Vdout0_0ck88 = 3.3 time = 890
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=890.05n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 890
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=890.05n

* CHECK dout0_2 Vdout0_2ck88 = 0 time = 890
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=890.05n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 890
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=890.05n

* CHECK dout0_4 Vdout0_4ck88 = 0 time = 890
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=890.05n

* CHECK dout0_5 Vdout0_5ck88 = 3.3 time = 890
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=890.05n

* CHECK dout0_6 Vdout0_6ck88 = 3.3 time = 890
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=890.05n

* CHECK dout0_7 Vdout0_7ck88 = 0 time = 890
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=890.05n

* CHECK dout0_0 Vdout0_0ck92 = 3.3 time = 930
.meas tran vdout0_0ck92 FIND v(dout0_0) AT=930.05n

* CHECK dout0_1 Vdout0_1ck92 = 0 time = 930
.meas tran vdout0_1ck92 FIND v(dout0_1) AT=930.05n

* CHECK dout0_2 Vdout0_2ck92 = 0 time = 930
.meas tran vdout0_2ck92 FIND v(dout0_2) AT=930.05n

* CHECK dout0_3 Vdout0_3ck92 = 0 time = 930
.meas tran vdout0_3ck92 FIND v(dout0_3) AT=930.05n

* CHECK dout0_4 Vdout0_4ck92 = 0 time = 930
.meas tran vdout0_4ck92 FIND v(dout0_4) AT=930.05n

* CHECK dout0_5 Vdout0_5ck92 = 3.3 time = 930
.meas tran vdout0_5ck92 FIND v(dout0_5) AT=930.05n

* CHECK dout0_6 Vdout0_6ck92 = 3.3 time = 930
.meas tran vdout0_6ck92 FIND v(dout0_6) AT=930.05n

* CHECK dout0_7 Vdout0_7ck92 = 0 time = 930
.meas tran vdout0_7ck92 FIND v(dout0_7) AT=930.05n

* CHECK dout0_0 Vdout0_0ck95 = 3.3 time = 960
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=960.05n

* CHECK dout0_1 Vdout0_1ck95 = 0 time = 960
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=960.05n

* CHECK dout0_2 Vdout0_2ck95 = 0 time = 960
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=960.05n

* CHECK dout0_3 Vdout0_3ck95 = 0 time = 960
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=960.05n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 960
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=960.05n

* CHECK dout0_5 Vdout0_5ck95 = 3.3 time = 960
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=960.05n

* CHECK dout0_6 Vdout0_6ck95 = 3.3 time = 960
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=960.05n

* CHECK dout0_7 Vdout0_7ck95 = 0 time = 960
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=960.05n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 970
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=970.05n

* CHECK dout0_1 Vdout0_1ck96 = 3.3 time = 970
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=970.05n

* CHECK dout0_2 Vdout0_2ck96 = 3.3 time = 970
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=970.05n

* CHECK dout0_3 Vdout0_3ck96 = 0 time = 970
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=970.05n

* CHECK dout0_4 Vdout0_4ck96 = 3.3 time = 970
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=970.05n

* CHECK dout0_5 Vdout0_5ck96 = 3.3 time = 970
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=970.05n

* CHECK dout0_6 Vdout0_6ck96 = 0 time = 970
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=970.05n

* CHECK dout0_7 Vdout0_7ck96 = 3.3 time = 970
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=970.05n

* CHECK dout0_0 Vdout0_0ck97 = 3.3 time = 980
.meas tran vdout0_0ck97 FIND v(dout0_0) AT=980.05n

* CHECK dout0_1 Vdout0_1ck97 = 0 time = 980
.meas tran vdout0_1ck97 FIND v(dout0_1) AT=980.05n

* CHECK dout0_2 Vdout0_2ck97 = 0 time = 980
.meas tran vdout0_2ck97 FIND v(dout0_2) AT=980.05n

* CHECK dout0_3 Vdout0_3ck97 = 0 time = 980
.meas tran vdout0_3ck97 FIND v(dout0_3) AT=980.05n

* CHECK dout0_4 Vdout0_4ck97 = 0 time = 980
.meas tran vdout0_4ck97 FIND v(dout0_4) AT=980.05n

* CHECK dout0_5 Vdout0_5ck97 = 3.3 time = 980
.meas tran vdout0_5ck97 FIND v(dout0_5) AT=980.05n

* CHECK dout0_6 Vdout0_6ck97 = 3.3 time = 980
.meas tran vdout0_6ck97 FIND v(dout0_6) AT=980.05n

* CHECK dout0_7 Vdout0_7ck97 = 0 time = 980
.meas tran vdout0_7ck97 FIND v(dout0_7) AT=980.05n

* CHECK dout0_0 Vdout0_0ck98 = 3.3 time = 990
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=990.05n

* CHECK dout0_1 Vdout0_1ck98 = 0 time = 990
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=990.05n

* CHECK dout0_2 Vdout0_2ck98 = 0 time = 990
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=990.05n

* CHECK dout0_3 Vdout0_3ck98 = 0 time = 990
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=990.05n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 990
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=990.05n

* CHECK dout0_5 Vdout0_5ck98 = 3.3 time = 990
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=990.05n

* CHECK dout0_6 Vdout0_6ck98 = 3.3 time = 990
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=990.05n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 990
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=990.05n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 1000
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=1000.05n

* CHECK dout0_1 Vdout0_1ck99 = 3.3 time = 1000
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=1000.05n

* CHECK dout0_2 Vdout0_2ck99 = 3.3 time = 1000
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=1000.05n

* CHECK dout0_3 Vdout0_3ck99 = 0 time = 1000
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=1000.05n

* CHECK dout0_4 Vdout0_4ck99 = 3.3 time = 1000
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=1000.05n

* CHECK dout0_5 Vdout0_5ck99 = 3.3 time = 1000
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=1000.05n

* CHECK dout0_6 Vdout0_6ck99 = 0 time = 1000
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=1000.05n

* CHECK dout0_7 Vdout0_7ck99 = 3.3 time = 1000
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=1000.05n

* CHECK dout0_0 Vdout0_0ck101 = 0 time = 1020
.meas tran vdout0_0ck101 FIND v(dout0_0) AT=1020.05n

* CHECK dout0_1 Vdout0_1ck101 = 3.3 time = 1020
.meas tran vdout0_1ck101 FIND v(dout0_1) AT=1020.05n

* CHECK dout0_2 Vdout0_2ck101 = 0 time = 1020
.meas tran vdout0_2ck101 FIND v(dout0_2) AT=1020.05n

* CHECK dout0_3 Vdout0_3ck101 = 3.3 time = 1020
.meas tran vdout0_3ck101 FIND v(dout0_3) AT=1020.05n

* CHECK dout0_4 Vdout0_4ck101 = 0 time = 1020
.meas tran vdout0_4ck101 FIND v(dout0_4) AT=1020.05n

* CHECK dout0_5 Vdout0_5ck101 = 3.3 time = 1020
.meas tran vdout0_5ck101 FIND v(dout0_5) AT=1020.05n

* CHECK dout0_6 Vdout0_6ck101 = 0 time = 1020
.meas tran vdout0_6ck101 FIND v(dout0_6) AT=1020.05n

* CHECK dout0_7 Vdout0_7ck101 = 3.3 time = 1020
.meas tran vdout0_7ck101 FIND v(dout0_7) AT=1020.05n

* CHECK dout0_0 Vdout0_0ck105 = 0 time = 1060
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=1060.05n

* CHECK dout0_1 Vdout0_1ck105 = 3.3 time = 1060
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=1060.05n

* CHECK dout0_2 Vdout0_2ck105 = 0 time = 1060
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=1060.05n

* CHECK dout0_3 Vdout0_3ck105 = 3.3 time = 1060
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=1060.05n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 1060
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=1060.05n

* CHECK dout0_5 Vdout0_5ck105 = 3.3 time = 1060
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=1060.05n

* CHECK dout0_6 Vdout0_6ck105 = 0 time = 1060
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=1060.05n

* CHECK dout0_7 Vdout0_7ck105 = 3.3 time = 1060
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=1060.05n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 1070
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=1070.05n

* CHECK dout0_1 Vdout0_1ck106 = 3.3 time = 1070
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=1070.05n

* CHECK dout0_2 Vdout0_2ck106 = 0 time = 1070
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=1070.05n

* CHECK dout0_3 Vdout0_3ck106 = 3.3 time = 1070
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=1070.05n

* CHECK dout0_4 Vdout0_4ck106 = 0 time = 1070
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=1070.05n

* CHECK dout0_5 Vdout0_5ck106 = 3.3 time = 1070
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=1070.05n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 1070
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=1070.05n

* CHECK dout0_7 Vdout0_7ck106 = 3.3 time = 1070
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=1070.05n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 1090
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=1090.05n

* CHECK dout0_1 Vdout0_1ck108 = 3.3 time = 1090
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=1090.05n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 1090
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=1090.05n

* CHECK dout0_3 Vdout0_3ck108 = 3.3 time = 1090
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=1090.05n

* CHECK dout0_4 Vdout0_4ck108 = 0 time = 1090
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=1090.05n

* CHECK dout0_5 Vdout0_5ck108 = 3.3 time = 1090
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=1090.05n

* CHECK dout0_6 Vdout0_6ck108 = 0 time = 1090
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=1090.05n

* CHECK dout0_7 Vdout0_7ck108 = 3.3 time = 1090
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=1090.05n

* CHECK dout0_0 Vdout0_0ck109 = 0 time = 1100
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=1100.05n

* CHECK dout0_1 Vdout0_1ck109 = 3.3 time = 1100
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=1100.05n

* CHECK dout0_2 Vdout0_2ck109 = 0 time = 1100
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=1100.05n

* CHECK dout0_3 Vdout0_3ck109 = 3.3 time = 1100
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=1100.05n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 1100
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=1100.05n

* CHECK dout0_5 Vdout0_5ck109 = 3.3 time = 1100
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=1100.05n

* CHECK dout0_6 Vdout0_6ck109 = 0 time = 1100
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=1100.05n

* CHECK dout0_7 Vdout0_7ck109 = 3.3 time = 1100
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=1100.05n

* CHECK dout0_0 Vdout0_0ck110 = 3.3 time = 1110
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=1110.05n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 1110
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=1110.05n

* CHECK dout0_2 Vdout0_2ck110 = 3.3 time = 1110
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=1110.05n

* CHECK dout0_3 Vdout0_3ck110 = 0 time = 1110
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=1110.05n

* CHECK dout0_4 Vdout0_4ck110 = 3.3 time = 1110
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=1110.05n

* CHECK dout0_5 Vdout0_5ck110 = 0 time = 1110
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=1110.05n

* CHECK dout0_6 Vdout0_6ck110 = 3.3 time = 1110
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=1110.05n

* CHECK dout0_7 Vdout0_7ck110 = 3.3 time = 1110
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=1110.05n

* CHECK dout0_0 Vdout0_0ck112 = 3.3 time = 1130
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=1130.05n

* CHECK dout0_1 Vdout0_1ck112 = 0 time = 1130
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=1130.05n

* CHECK dout0_2 Vdout0_2ck112 = 3.3 time = 1130
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=1130.05n

* CHECK dout0_3 Vdout0_3ck112 = 0 time = 1130
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=1130.05n

* CHECK dout0_4 Vdout0_4ck112 = 3.3 time = 1130
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=1130.05n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 1130
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=1130.05n

* CHECK dout0_6 Vdout0_6ck112 = 3.3 time = 1130
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=1130.05n

* CHECK dout0_7 Vdout0_7ck112 = 3.3 time = 1130
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=1130.05n

* CHECK dout0_0 Vdout0_0ck114 = 0 time = 1150
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=1150.05n

* CHECK dout0_1 Vdout0_1ck114 = 3.3 time = 1150
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=1150.05n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 1150
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=1150.05n

* CHECK dout0_3 Vdout0_3ck114 = 3.3 time = 1150
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=1150.05n

* CHECK dout0_4 Vdout0_4ck114 = 0 time = 1150
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=1150.05n

* CHECK dout0_5 Vdout0_5ck114 = 3.3 time = 1150
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=1150.05n

* CHECK dout0_6 Vdout0_6ck114 = 0 time = 1150
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=1150.05n

* CHECK dout0_7 Vdout0_7ck114 = 3.3 time = 1150
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=1150.05n

* CHECK dout0_0 Vdout0_0ck117 = 3.3 time = 1180
.meas tran vdout0_0ck117 FIND v(dout0_0) AT=1180.05n

* CHECK dout0_1 Vdout0_1ck117 = 3.3 time = 1180
.meas tran vdout0_1ck117 FIND v(dout0_1) AT=1180.05n

* CHECK dout0_2 Vdout0_2ck117 = 3.3 time = 1180
.meas tran vdout0_2ck117 FIND v(dout0_2) AT=1180.05n

* CHECK dout0_3 Vdout0_3ck117 = 3.3 time = 1180
.meas tran vdout0_3ck117 FIND v(dout0_3) AT=1180.05n

* CHECK dout0_4 Vdout0_4ck117 = 3.3 time = 1180
.meas tran vdout0_4ck117 FIND v(dout0_4) AT=1180.05n

* CHECK dout0_5 Vdout0_5ck117 = 0 time = 1180
.meas tran vdout0_5ck117 FIND v(dout0_5) AT=1180.05n

* CHECK dout0_6 Vdout0_6ck117 = 0 time = 1180
.meas tran vdout0_6ck117 FIND v(dout0_6) AT=1180.05n

* CHECK dout0_7 Vdout0_7ck117 = 0 time = 1180
.meas tran vdout0_7ck117 FIND v(dout0_7) AT=1180.05n

* CHECK dout0_0 Vdout0_0ck120 = 0 time = 1210
.meas tran vdout0_0ck120 FIND v(dout0_0) AT=1210.05n

* CHECK dout0_1 Vdout0_1ck120 = 3.3 time = 1210
.meas tran vdout0_1ck120 FIND v(dout0_1) AT=1210.05n

* CHECK dout0_2 Vdout0_2ck120 = 3.3 time = 1210
.meas tran vdout0_2ck120 FIND v(dout0_2) AT=1210.05n

* CHECK dout0_3 Vdout0_3ck120 = 0 time = 1210
.meas tran vdout0_3ck120 FIND v(dout0_3) AT=1210.05n

* CHECK dout0_4 Vdout0_4ck120 = 0 time = 1210
.meas tran vdout0_4ck120 FIND v(dout0_4) AT=1210.05n

* CHECK dout0_5 Vdout0_5ck120 = 0 time = 1210
.meas tran vdout0_5ck120 FIND v(dout0_5) AT=1210.05n

* CHECK dout0_6 Vdout0_6ck120 = 0 time = 1210
.meas tran vdout0_6ck120 FIND v(dout0_6) AT=1210.05n

* CHECK dout0_7 Vdout0_7ck120 = 0 time = 1210
.meas tran vdout0_7ck120 FIND v(dout0_7) AT=1210.05n

* CHECK dout0_0 Vdout0_0ck126 = 3.3 time = 1270
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=1270.05n

* CHECK dout0_1 Vdout0_1ck126 = 3.3 time = 1270
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=1270.05n

* CHECK dout0_2 Vdout0_2ck126 = 3.3 time = 1270
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=1270.05n

* CHECK dout0_3 Vdout0_3ck126 = 3.3 time = 1270
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=1270.05n

* CHECK dout0_4 Vdout0_4ck126 = 3.3 time = 1270
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=1270.05n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 1270
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=1270.05n

* CHECK dout0_6 Vdout0_6ck126 = 0 time = 1270
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=1270.05n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 1270
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=1270.05n

* CHECK dout0_0 Vdout0_0ck127 = 3.3 time = 1280
.meas tran vdout0_0ck127 FIND v(dout0_0) AT=1280.05n

* CHECK dout0_1 Vdout0_1ck127 = 3.3 time = 1280
.meas tran vdout0_1ck127 FIND v(dout0_1) AT=1280.05n

* CHECK dout0_2 Vdout0_2ck127 = 3.3 time = 1280
.meas tran vdout0_2ck127 FIND v(dout0_2) AT=1280.05n

* CHECK dout0_3 Vdout0_3ck127 = 3.3 time = 1280
.meas tran vdout0_3ck127 FIND v(dout0_3) AT=1280.05n

* CHECK dout0_4 Vdout0_4ck127 = 3.3 time = 1280
.meas tran vdout0_4ck127 FIND v(dout0_4) AT=1280.05n

* CHECK dout0_5 Vdout0_5ck127 = 0 time = 1280
.meas tran vdout0_5ck127 FIND v(dout0_5) AT=1280.05n

* CHECK dout0_6 Vdout0_6ck127 = 0 time = 1280
.meas tran vdout0_6ck127 FIND v(dout0_6) AT=1280.05n

* CHECK dout0_7 Vdout0_7ck127 = 0 time = 1280
.meas tran vdout0_7ck127 FIND v(dout0_7) AT=1280.05n

* CHECK dout0_0 Vdout0_0ck130 = 3.3 time = 1310
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=1310.05n

* CHECK dout0_1 Vdout0_1ck130 = 3.3 time = 1310
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=1310.05n

* CHECK dout0_2 Vdout0_2ck130 = 0 time = 1310
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=1310.05n

* CHECK dout0_3 Vdout0_3ck130 = 3.3 time = 1310
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=1310.05n

* CHECK dout0_4 Vdout0_4ck130 = 3.3 time = 1310
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=1310.05n

* CHECK dout0_5 Vdout0_5ck130 = 3.3 time = 1310
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=1310.05n

* CHECK dout0_6 Vdout0_6ck130 = 3.3 time = 1310
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=1310.05n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 1310
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=1310.05n

* CHECK dout0_0 Vdout0_0ck131 = 0 time = 1320
.meas tran vdout0_0ck131 FIND v(dout0_0) AT=1320.05n

* CHECK dout0_1 Vdout0_1ck131 = 0 time = 1320
.meas tran vdout0_1ck131 FIND v(dout0_1) AT=1320.05n

* CHECK dout0_2 Vdout0_2ck131 = 3.3 time = 1320
.meas tran vdout0_2ck131 FIND v(dout0_2) AT=1320.05n

* CHECK dout0_3 Vdout0_3ck131 = 3.3 time = 1320
.meas tran vdout0_3ck131 FIND v(dout0_3) AT=1320.05n

* CHECK dout0_4 Vdout0_4ck131 = 3.3 time = 1320
.meas tran vdout0_4ck131 FIND v(dout0_4) AT=1320.05n

* CHECK dout0_5 Vdout0_5ck131 = 0 time = 1320
.meas tran vdout0_5ck131 FIND v(dout0_5) AT=1320.05n

* CHECK dout0_6 Vdout0_6ck131 = 3.3 time = 1320
.meas tran vdout0_6ck131 FIND v(dout0_6) AT=1320.05n

* CHECK dout0_7 Vdout0_7ck131 = 3.3 time = 1320
.meas tran vdout0_7ck131 FIND v(dout0_7) AT=1320.05n

* CHECK dout0_0 Vdout0_0ck132 = 3.3 time = 1330
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=1330.05n

* CHECK dout0_1 Vdout0_1ck132 = 3.3 time = 1330
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=1330.05n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 1330
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=1330.05n

* CHECK dout0_3 Vdout0_3ck132 = 3.3 time = 1330
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=1330.05n

* CHECK dout0_4 Vdout0_4ck132 = 3.3 time = 1330
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=1330.05n

* CHECK dout0_5 Vdout0_5ck132 = 3.3 time = 1330
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=1330.05n

* CHECK dout0_6 Vdout0_6ck132 = 3.3 time = 1330
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=1330.05n

* CHECK dout0_7 Vdout0_7ck132 = 0 time = 1330
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=1330.05n

* CHECK dout0_0 Vdout0_0ck133 = 3.3 time = 1340
.meas tran vdout0_0ck133 FIND v(dout0_0) AT=1340.05n

* CHECK dout0_1 Vdout0_1ck133 = 3.3 time = 1340
.meas tran vdout0_1ck133 FIND v(dout0_1) AT=1340.05n

* CHECK dout0_2 Vdout0_2ck133 = 0 time = 1340
.meas tran vdout0_2ck133 FIND v(dout0_2) AT=1340.05n

* CHECK dout0_3 Vdout0_3ck133 = 3.3 time = 1340
.meas tran vdout0_3ck133 FIND v(dout0_3) AT=1340.05n

* CHECK dout0_4 Vdout0_4ck133 = 3.3 time = 1340
.meas tran vdout0_4ck133 FIND v(dout0_4) AT=1340.05n

* CHECK dout0_5 Vdout0_5ck133 = 3.3 time = 1340
.meas tran vdout0_5ck133 FIND v(dout0_5) AT=1340.05n

* CHECK dout0_6 Vdout0_6ck133 = 3.3 time = 1340
.meas tran vdout0_6ck133 FIND v(dout0_6) AT=1340.05n

* CHECK dout0_7 Vdout0_7ck133 = 0 time = 1340
.meas tran vdout0_7ck133 FIND v(dout0_7) AT=1340.05n

* CHECK dout0_0 Vdout0_0ck134 = 0 time = 1350
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=1350.05n

* CHECK dout0_1 Vdout0_1ck134 = 0 time = 1350
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=1350.05n

* CHECK dout0_2 Vdout0_2ck134 = 3.3 time = 1350
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=1350.05n

* CHECK dout0_3 Vdout0_3ck134 = 3.3 time = 1350
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=1350.05n

* CHECK dout0_4 Vdout0_4ck134 = 3.3 time = 1350
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=1350.05n

* CHECK dout0_5 Vdout0_5ck134 = 0 time = 1350
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=1350.05n

* CHECK dout0_6 Vdout0_6ck134 = 3.3 time = 1350
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=1350.05n

* CHECK dout0_7 Vdout0_7ck134 = 3.3 time = 1350
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=1350.05n

* CHECK dout0_0 Vdout0_0ck136 = 0 time = 1370
.meas tran vdout0_0ck136 FIND v(dout0_0) AT=1370.05n

* CHECK dout0_1 Vdout0_1ck136 = 0 time = 1370
.meas tran vdout0_1ck136 FIND v(dout0_1) AT=1370.05n

* CHECK dout0_2 Vdout0_2ck136 = 0 time = 1370
.meas tran vdout0_2ck136 FIND v(dout0_2) AT=1370.05n

* CHECK dout0_3 Vdout0_3ck136 = 0 time = 1370
.meas tran vdout0_3ck136 FIND v(dout0_3) AT=1370.05n

* CHECK dout0_4 Vdout0_4ck136 = 3.3 time = 1370
.meas tran vdout0_4ck136 FIND v(dout0_4) AT=1370.05n

* CHECK dout0_5 Vdout0_5ck136 = 0 time = 1370
.meas tran vdout0_5ck136 FIND v(dout0_5) AT=1370.05n

* CHECK dout0_6 Vdout0_6ck136 = 3.3 time = 1370
.meas tran vdout0_6ck136 FIND v(dout0_6) AT=1370.05n

* CHECK dout0_7 Vdout0_7ck136 = 0 time = 1370
.meas tran vdout0_7ck136 FIND v(dout0_7) AT=1370.05n

* CHECK dout0_0 Vdout0_0ck137 = 0 time = 1380
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=1380.05n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 1380
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=1380.05n

* CHECK dout0_2 Vdout0_2ck137 = 0 time = 1380
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=1380.05n

* CHECK dout0_3 Vdout0_3ck137 = 0 time = 1380
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=1380.05n

* CHECK dout0_4 Vdout0_4ck137 = 3.3 time = 1380
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=1380.05n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 1380
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=1380.05n

* CHECK dout0_6 Vdout0_6ck137 = 3.3 time = 1380
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=1380.05n

* CHECK dout0_7 Vdout0_7ck137 = 0 time = 1380
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=1380.05n

* CHECK dout0_0 Vdout0_0ck138 = 3.3 time = 1390
.meas tran vdout0_0ck138 FIND v(dout0_0) AT=1390.05n

* CHECK dout0_1 Vdout0_1ck138 = 3.3 time = 1390
.meas tran vdout0_1ck138 FIND v(dout0_1) AT=1390.05n

* CHECK dout0_2 Vdout0_2ck138 = 0 time = 1390
.meas tran vdout0_2ck138 FIND v(dout0_2) AT=1390.05n

* CHECK dout0_3 Vdout0_3ck138 = 3.3 time = 1390
.meas tran vdout0_3ck138 FIND v(dout0_3) AT=1390.05n

* CHECK dout0_4 Vdout0_4ck138 = 3.3 time = 1390
.meas tran vdout0_4ck138 FIND v(dout0_4) AT=1390.05n

* CHECK dout0_5 Vdout0_5ck138 = 3.3 time = 1390
.meas tran vdout0_5ck138 FIND v(dout0_5) AT=1390.05n

* CHECK dout0_6 Vdout0_6ck138 = 3.3 time = 1390
.meas tran vdout0_6ck138 FIND v(dout0_6) AT=1390.05n

* CHECK dout0_7 Vdout0_7ck138 = 0 time = 1390
.meas tran vdout0_7ck138 FIND v(dout0_7) AT=1390.05n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 1400
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=1400.05n

* CHECK dout0_1 Vdout0_1ck139 = 0 time = 1400
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=1400.05n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 1400
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=1400.05n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 1400
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=1400.05n

* CHECK dout0_4 Vdout0_4ck139 = 3.3 time = 1400
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=1400.05n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 1400
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=1400.05n

* CHECK dout0_6 Vdout0_6ck139 = 3.3 time = 1400
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=1400.05n

* CHECK dout0_7 Vdout0_7ck139 = 0 time = 1400
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=1400.05n

* CHECK dout0_0 Vdout0_0ck142 = 0 time = 1430
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=1430.05n

* CHECK dout0_1 Vdout0_1ck142 = 0 time = 1430
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=1430.05n

* CHECK dout0_2 Vdout0_2ck142 = 0 time = 1430
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=1430.05n

* CHECK dout0_3 Vdout0_3ck142 = 0 time = 1430
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=1430.05n

* CHECK dout0_4 Vdout0_4ck142 = 3.3 time = 1430
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=1430.05n

* CHECK dout0_5 Vdout0_5ck142 = 0 time = 1430
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=1430.05n

* CHECK dout0_6 Vdout0_6ck142 = 3.3 time = 1430
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=1430.05n

* CHECK dout0_7 Vdout0_7ck142 = 0 time = 1430
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=1430.05n

* CHECK dout0_0 Vdout0_0ck144 = 0 time = 1450
.meas tran vdout0_0ck144 FIND v(dout0_0) AT=1450.05n

* CHECK dout0_1 Vdout0_1ck144 = 0 time = 1450
.meas tran vdout0_1ck144 FIND v(dout0_1) AT=1450.05n

* CHECK dout0_2 Vdout0_2ck144 = 0 time = 1450
.meas tran vdout0_2ck144 FIND v(dout0_2) AT=1450.05n

* CHECK dout0_3 Vdout0_3ck144 = 0 time = 1450
.meas tran vdout0_3ck144 FIND v(dout0_3) AT=1450.05n

* CHECK dout0_4 Vdout0_4ck144 = 3.3 time = 1450
.meas tran vdout0_4ck144 FIND v(dout0_4) AT=1450.05n

* CHECK dout0_5 Vdout0_5ck144 = 0 time = 1450
.meas tran vdout0_5ck144 FIND v(dout0_5) AT=1450.05n

* CHECK dout0_6 Vdout0_6ck144 = 3.3 time = 1450
.meas tran vdout0_6ck144 FIND v(dout0_6) AT=1450.05n

* CHECK dout0_7 Vdout0_7ck144 = 0 time = 1450
.meas tran vdout0_7ck144 FIND v(dout0_7) AT=1450.05n

* CHECK dout0_0 Vdout0_0ck146 = 3.3 time = 1470
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=1470.05n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 1470
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=1470.05n

* CHECK dout0_2 Vdout0_2ck146 = 0 time = 1470
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=1470.05n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 1470
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=1470.05n

* CHECK dout0_4 Vdout0_4ck146 = 0 time = 1470
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=1470.05n

* CHECK dout0_5 Vdout0_5ck146 = 0 time = 1470
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=1470.05n

* CHECK dout0_6 Vdout0_6ck146 = 3.3 time = 1470
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=1470.05n

* CHECK dout0_7 Vdout0_7ck146 = 0 time = 1470
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=1470.05n

* CHECK dout0_0 Vdout0_0ck147 = 3.3 time = 1480
.meas tran vdout0_0ck147 FIND v(dout0_0) AT=1480.05n

* CHECK dout0_1 Vdout0_1ck147 = 0 time = 1480
.meas tran vdout0_1ck147 FIND v(dout0_1) AT=1480.05n

* CHECK dout0_2 Vdout0_2ck147 = 0 time = 1480
.meas tran vdout0_2ck147 FIND v(dout0_2) AT=1480.05n

* CHECK dout0_3 Vdout0_3ck147 = 0 time = 1480
.meas tran vdout0_3ck147 FIND v(dout0_3) AT=1480.05n

* CHECK dout0_4 Vdout0_4ck147 = 0 time = 1480
.meas tran vdout0_4ck147 FIND v(dout0_4) AT=1480.05n

* CHECK dout0_5 Vdout0_5ck147 = 0 time = 1480
.meas tran vdout0_5ck147 FIND v(dout0_5) AT=1480.05n

* CHECK dout0_6 Vdout0_6ck147 = 3.3 time = 1480
.meas tran vdout0_6ck147 FIND v(dout0_6) AT=1480.05n

* CHECK dout0_7 Vdout0_7ck147 = 0 time = 1480
.meas tran vdout0_7ck147 FIND v(dout0_7) AT=1480.05n

* CHECK dout0_0 Vdout0_0ck148 = 3.3 time = 1490
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=1490.05n

* CHECK dout0_1 Vdout0_1ck148 = 0 time = 1490
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=1490.05n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 1490
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=1490.05n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 1490
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=1490.05n

* CHECK dout0_4 Vdout0_4ck148 = 0 time = 1490
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=1490.05n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 1490
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=1490.05n

* CHECK dout0_6 Vdout0_6ck148 = 3.3 time = 1490
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=1490.05n

* CHECK dout0_7 Vdout0_7ck148 = 0 time = 1490
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=1490.05n

* CHECK dout0_0 Vdout0_0ck149 = 3.3 time = 1500
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=1500.05n

* CHECK dout0_1 Vdout0_1ck149 = 0 time = 1500
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=1500.05n

* CHECK dout0_2 Vdout0_2ck149 = 0 time = 1500
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=1500.05n

* CHECK dout0_3 Vdout0_3ck149 = 0 time = 1500
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=1500.05n

* CHECK dout0_4 Vdout0_4ck149 = 0 time = 1500
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=1500.05n

* CHECK dout0_5 Vdout0_5ck149 = 0 time = 1500
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=1500.05n

* CHECK dout0_6 Vdout0_6ck149 = 3.3 time = 1500
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=1500.05n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 1500
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=1500.05n

* CHECK dout0_0 Vdout0_0ck150 = 0 time = 1510
.meas tran vdout0_0ck150 FIND v(dout0_0) AT=1510.05n

* CHECK dout0_1 Vdout0_1ck150 = 0 time = 1510
.meas tran vdout0_1ck150 FIND v(dout0_1) AT=1510.05n

* CHECK dout0_2 Vdout0_2ck150 = 0 time = 1510
.meas tran vdout0_2ck150 FIND v(dout0_2) AT=1510.05n

* CHECK dout0_3 Vdout0_3ck150 = 0 time = 1510
.meas tran vdout0_3ck150 FIND v(dout0_3) AT=1510.05n

* CHECK dout0_4 Vdout0_4ck150 = 3.3 time = 1510
.meas tran vdout0_4ck150 FIND v(dout0_4) AT=1510.05n

* CHECK dout0_5 Vdout0_5ck150 = 0 time = 1510
.meas tran vdout0_5ck150 FIND v(dout0_5) AT=1510.05n

* CHECK dout0_6 Vdout0_6ck150 = 3.3 time = 1510
.meas tran vdout0_6ck150 FIND v(dout0_6) AT=1510.05n

* CHECK dout0_7 Vdout0_7ck150 = 0 time = 1510
.meas tran vdout0_7ck150 FIND v(dout0_7) AT=1510.05n

* CHECK dout0_0 Vdout0_0ck151 = 0 time = 1520
.meas tran vdout0_0ck151 FIND v(dout0_0) AT=1520.05n

* CHECK dout0_1 Vdout0_1ck151 = 0 time = 1520
.meas tran vdout0_1ck151 FIND v(dout0_1) AT=1520.05n

* CHECK dout0_2 Vdout0_2ck151 = 0 time = 1520
.meas tran vdout0_2ck151 FIND v(dout0_2) AT=1520.05n

* CHECK dout0_3 Vdout0_3ck151 = 0 time = 1520
.meas tran vdout0_3ck151 FIND v(dout0_3) AT=1520.05n

* CHECK dout0_4 Vdout0_4ck151 = 3.3 time = 1520
.meas tran vdout0_4ck151 FIND v(dout0_4) AT=1520.05n

* CHECK dout0_5 Vdout0_5ck151 = 0 time = 1520
.meas tran vdout0_5ck151 FIND v(dout0_5) AT=1520.05n

* CHECK dout0_6 Vdout0_6ck151 = 3.3 time = 1520
.meas tran vdout0_6ck151 FIND v(dout0_6) AT=1520.05n

* CHECK dout0_7 Vdout0_7ck151 = 0 time = 1520
.meas tran vdout0_7ck151 FIND v(dout0_7) AT=1520.05n

* CHECK dout0_0 Vdout0_0ck153 = 3.3 time = 1540
.meas tran vdout0_0ck153 FIND v(dout0_0) AT=1540.05n

* CHECK dout0_1 Vdout0_1ck153 = 0 time = 1540
.meas tran vdout0_1ck153 FIND v(dout0_1) AT=1540.05n

* CHECK dout0_2 Vdout0_2ck153 = 0 time = 1540
.meas tran vdout0_2ck153 FIND v(dout0_2) AT=1540.05n

* CHECK dout0_3 Vdout0_3ck153 = 0 time = 1540
.meas tran vdout0_3ck153 FIND v(dout0_3) AT=1540.05n

* CHECK dout0_4 Vdout0_4ck153 = 3.3 time = 1540
.meas tran vdout0_4ck153 FIND v(dout0_4) AT=1540.05n

* CHECK dout0_5 Vdout0_5ck153 = 0 time = 1540
.meas tran vdout0_5ck153 FIND v(dout0_5) AT=1540.05n

* CHECK dout0_6 Vdout0_6ck153 = 3.3 time = 1540
.meas tran vdout0_6ck153 FIND v(dout0_6) AT=1540.05n

* CHECK dout0_7 Vdout0_7ck153 = 3.3 time = 1540
.meas tran vdout0_7ck153 FIND v(dout0_7) AT=1540.05n

* CHECK dout0_0 Vdout0_0ck154 = 3.3 time = 1550
.meas tran vdout0_0ck154 FIND v(dout0_0) AT=1550.05n

* CHECK dout0_1 Vdout0_1ck154 = 0 time = 1550
.meas tran vdout0_1ck154 FIND v(dout0_1) AT=1550.05n

* CHECK dout0_2 Vdout0_2ck154 = 0 time = 1550
.meas tran vdout0_2ck154 FIND v(dout0_2) AT=1550.05n

* CHECK dout0_3 Vdout0_3ck154 = 0 time = 1550
.meas tran vdout0_3ck154 FIND v(dout0_3) AT=1550.05n

* CHECK dout0_4 Vdout0_4ck154 = 0 time = 1550
.meas tran vdout0_4ck154 FIND v(dout0_4) AT=1550.05n

* CHECK dout0_5 Vdout0_5ck154 = 0 time = 1550
.meas tran vdout0_5ck154 FIND v(dout0_5) AT=1550.05n

* CHECK dout0_6 Vdout0_6ck154 = 3.3 time = 1550
.meas tran vdout0_6ck154 FIND v(dout0_6) AT=1550.05n

* CHECK dout0_7 Vdout0_7ck154 = 0 time = 1550
.meas tran vdout0_7ck154 FIND v(dout0_7) AT=1550.05n

* CHECK dout0_0 Vdout0_0ck155 = 3.3 time = 1560
.meas tran vdout0_0ck155 FIND v(dout0_0) AT=1560.05n

* CHECK dout0_1 Vdout0_1ck155 = 0 time = 1560
.meas tran vdout0_1ck155 FIND v(dout0_1) AT=1560.05n

* CHECK dout0_2 Vdout0_2ck155 = 0 time = 1560
.meas tran vdout0_2ck155 FIND v(dout0_2) AT=1560.05n

* CHECK dout0_3 Vdout0_3ck155 = 0 time = 1560
.meas tran vdout0_3ck155 FIND v(dout0_3) AT=1560.05n

* CHECK dout0_4 Vdout0_4ck155 = 3.3 time = 1560
.meas tran vdout0_4ck155 FIND v(dout0_4) AT=1560.05n

* CHECK dout0_5 Vdout0_5ck155 = 0 time = 1560
.meas tran vdout0_5ck155 FIND v(dout0_5) AT=1560.05n

* CHECK dout0_6 Vdout0_6ck155 = 3.3 time = 1560
.meas tran vdout0_6ck155 FIND v(dout0_6) AT=1560.05n

* CHECK dout0_7 Vdout0_7ck155 = 3.3 time = 1560
.meas tran vdout0_7ck155 FIND v(dout0_7) AT=1560.05n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 1610
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=1610.05n

* CHECK dout0_1 Vdout0_1ck160 = 3.3 time = 1610
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=1610.05n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 1610
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=1610.05n

* CHECK dout0_3 Vdout0_3ck160 = 3.3 time = 1610
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=1610.05n

* CHECK dout0_4 Vdout0_4ck160 = 0 time = 1610
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=1610.05n

* CHECK dout0_5 Vdout0_5ck160 = 3.3 time = 1610
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=1610.05n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 1610
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=1610.05n

* CHECK dout0_7 Vdout0_7ck160 = 0 time = 1610
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=1610.05n

* CHECK dout0_0 Vdout0_0ck161 = 0 time = 1620
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=1620.05n

* CHECK dout0_1 Vdout0_1ck161 = 3.3 time = 1620
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=1620.05n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 1620
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=1620.05n

* CHECK dout0_3 Vdout0_3ck161 = 3.3 time = 1620
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=1620.05n

* CHECK dout0_4 Vdout0_4ck161 = 0 time = 1620
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=1620.05n

* CHECK dout0_5 Vdout0_5ck161 = 3.3 time = 1620
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=1620.05n

* CHECK dout0_6 Vdout0_6ck161 = 0 time = 1620
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=1620.05n

* CHECK dout0_7 Vdout0_7ck161 = 0 time = 1620
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=1620.05n

* CHECK dout0_0 Vdout0_0ck163 = 0 time = 1640
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=1640.05n

* CHECK dout0_1 Vdout0_1ck163 = 3.3 time = 1640
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=1640.05n

* CHECK dout0_2 Vdout0_2ck163 = 0 time = 1640
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=1640.05n

* CHECK dout0_3 Vdout0_3ck163 = 3.3 time = 1640
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=1640.05n

* CHECK dout0_4 Vdout0_4ck163 = 0 time = 1640
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=1640.05n

* CHECK dout0_5 Vdout0_5ck163 = 3.3 time = 1640
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=1640.05n

* CHECK dout0_6 Vdout0_6ck163 = 0 time = 1640
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=1640.05n

* CHECK dout0_7 Vdout0_7ck163 = 0 time = 1640
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=1640.05n

* CHECK dout0_0 Vdout0_0ck164 = 3.3 time = 1650
.meas tran vdout0_0ck164 FIND v(dout0_0) AT=1650.05n

* CHECK dout0_1 Vdout0_1ck164 = 3.3 time = 1650
.meas tran vdout0_1ck164 FIND v(dout0_1) AT=1650.05n

* CHECK dout0_2 Vdout0_2ck164 = 3.3 time = 1650
.meas tran vdout0_2ck164 FIND v(dout0_2) AT=1650.05n

* CHECK dout0_3 Vdout0_3ck164 = 3.3 time = 1650
.meas tran vdout0_3ck164 FIND v(dout0_3) AT=1650.05n

* CHECK dout0_4 Vdout0_4ck164 = 0 time = 1650
.meas tran vdout0_4ck164 FIND v(dout0_4) AT=1650.05n

* CHECK dout0_5 Vdout0_5ck164 = 0 time = 1650
.meas tran vdout0_5ck164 FIND v(dout0_5) AT=1650.05n

* CHECK dout0_6 Vdout0_6ck164 = 0 time = 1650
.meas tran vdout0_6ck164 FIND v(dout0_6) AT=1650.05n

* CHECK dout0_7 Vdout0_7ck164 = 3.3 time = 1650
.meas tran vdout0_7ck164 FIND v(dout0_7) AT=1650.05n

* CHECK dout0_0 Vdout0_0ck168 = 3.3 time = 1690
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=1690.05n

* CHECK dout0_1 Vdout0_1ck168 = 0 time = 1690
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=1690.05n

* CHECK dout0_2 Vdout0_2ck168 = 3.3 time = 1690
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=1690.05n

* CHECK dout0_3 Vdout0_3ck168 = 0 time = 1690
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=1690.05n

* CHECK dout0_4 Vdout0_4ck168 = 3.3 time = 1690
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=1690.05n

* CHECK dout0_5 Vdout0_5ck168 = 3.3 time = 1690
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=1690.05n

* CHECK dout0_6 Vdout0_6ck168 = 3.3 time = 1690
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=1690.05n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 1690
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=1690.05n

* CHECK dout0_0 Vdout0_0ck171 = 0 time = 1720
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=1720.05n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 1720
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=1720.05n

* CHECK dout0_2 Vdout0_2ck171 = 0 time = 1720
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=1720.05n

* CHECK dout0_3 Vdout0_3ck171 = 0 time = 1720
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=1720.05n

* CHECK dout0_4 Vdout0_4ck171 = 0 time = 1720
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=1720.05n

* CHECK dout0_5 Vdout0_5ck171 = 3.3 time = 1720
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=1720.05n

* CHECK dout0_6 Vdout0_6ck171 = 0 time = 1720
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=1720.05n

* CHECK dout0_7 Vdout0_7ck171 = 0 time = 1720
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=1720.05n

* CHECK dout0_0 Vdout0_0ck172 = 0 time = 1730
.meas tran vdout0_0ck172 FIND v(dout0_0) AT=1730.05n

* CHECK dout0_1 Vdout0_1ck172 = 0 time = 1730
.meas tran vdout0_1ck172 FIND v(dout0_1) AT=1730.05n

* CHECK dout0_2 Vdout0_2ck172 = 0 time = 1730
.meas tran vdout0_2ck172 FIND v(dout0_2) AT=1730.05n

* CHECK dout0_3 Vdout0_3ck172 = 0 time = 1730
.meas tran vdout0_3ck172 FIND v(dout0_3) AT=1730.05n

* CHECK dout0_4 Vdout0_4ck172 = 0 time = 1730
.meas tran vdout0_4ck172 FIND v(dout0_4) AT=1730.05n

* CHECK dout0_5 Vdout0_5ck172 = 3.3 time = 1730
.meas tran vdout0_5ck172 FIND v(dout0_5) AT=1730.05n

* CHECK dout0_6 Vdout0_6ck172 = 0 time = 1730
.meas tran vdout0_6ck172 FIND v(dout0_6) AT=1730.05n

* CHECK dout0_7 Vdout0_7ck172 = 0 time = 1730
.meas tran vdout0_7ck172 FIND v(dout0_7) AT=1730.05n

* CHECK dout0_0 Vdout0_0ck177 = 0 time = 1780
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=1780.05n

* CHECK dout0_1 Vdout0_1ck177 = 0 time = 1780
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=1780.05n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 1780
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=1780.05n

* CHECK dout0_3 Vdout0_3ck177 = 0 time = 1780
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=1780.05n

* CHECK dout0_4 Vdout0_4ck177 = 0 time = 1780
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=1780.05n

* CHECK dout0_5 Vdout0_5ck177 = 3.3 time = 1780
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=1780.05n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 1780
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=1780.05n

* CHECK dout0_7 Vdout0_7ck177 = 0 time = 1780
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=1780.05n

* CHECK dout0_0 Vdout0_0ck181 = 0 time = 1820
.meas tran vdout0_0ck181 FIND v(dout0_0) AT=1820.05n

* CHECK dout0_1 Vdout0_1ck181 = 0 time = 1820
.meas tran vdout0_1ck181 FIND v(dout0_1) AT=1820.05n

* CHECK dout0_2 Vdout0_2ck181 = 3.3 time = 1820
.meas tran vdout0_2ck181 FIND v(dout0_2) AT=1820.05n

* CHECK dout0_3 Vdout0_3ck181 = 3.3 time = 1820
.meas tran vdout0_3ck181 FIND v(dout0_3) AT=1820.05n

* CHECK dout0_4 Vdout0_4ck181 = 0 time = 1820
.meas tran vdout0_4ck181 FIND v(dout0_4) AT=1820.05n

* CHECK dout0_5 Vdout0_5ck181 = 0 time = 1820
.meas tran vdout0_5ck181 FIND v(dout0_5) AT=1820.05n

* CHECK dout0_6 Vdout0_6ck181 = 0 time = 1820
.meas tran vdout0_6ck181 FIND v(dout0_6) AT=1820.05n

* CHECK dout0_7 Vdout0_7ck181 = 0 time = 1820
.meas tran vdout0_7ck181 FIND v(dout0_7) AT=1820.05n

* CHECK dout0_0 Vdout0_0ck184 = 3.3 time = 1850
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=1850.05n

* CHECK dout0_1 Vdout0_1ck184 = 3.3 time = 1850
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=1850.05n

* CHECK dout0_2 Vdout0_2ck184 = 3.3 time = 1850
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=1850.05n

* CHECK dout0_3 Vdout0_3ck184 = 0 time = 1850
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=1850.05n

* CHECK dout0_4 Vdout0_4ck184 = 3.3 time = 1850
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=1850.05n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 1850
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=1850.05n

* CHECK dout0_6 Vdout0_6ck184 = 0 time = 1850
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=1850.05n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 1850
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=1850.05n

* CHECK dout0_0 Vdout0_0ck186 = 3.3 time = 1870
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=1870.05n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 1870
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=1870.05n

* CHECK dout0_2 Vdout0_2ck186 = 3.3 time = 1870
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=1870.05n

* CHECK dout0_3 Vdout0_3ck186 = 0 time = 1870
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=1870.05n

* CHECK dout0_4 Vdout0_4ck186 = 3.3 time = 1870
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=1870.05n

* CHECK dout0_5 Vdout0_5ck186 = 3.3 time = 1870
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=1870.05n

* CHECK dout0_6 Vdout0_6ck186 = 0 time = 1870
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=1870.05n

* CHECK dout0_7 Vdout0_7ck186 = 3.3 time = 1870
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=1870.05n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 1880
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=1880.05n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 1880
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=1880.05n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 1880
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=1880.05n

* CHECK dout0_3 Vdout0_3ck187 = 0 time = 1880
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=1880.05n

* CHECK dout0_4 Vdout0_4ck187 = 0 time = 1880
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=1880.05n

* CHECK dout0_5 Vdout0_5ck187 = 3.3 time = 1880
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=1880.05n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 1880
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=1880.05n

* CHECK dout0_7 Vdout0_7ck187 = 0 time = 1880
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=1880.05n

* CHECK dout0_0 Vdout0_0ck190 = 3.3 time = 1910
.meas tran vdout0_0ck190 FIND v(dout0_0) AT=1910.05n

* CHECK dout0_1 Vdout0_1ck190 = 0 time = 1910
.meas tran vdout0_1ck190 FIND v(dout0_1) AT=1910.05n

* CHECK dout0_2 Vdout0_2ck190 = 3.3 time = 1910
.meas tran vdout0_2ck190 FIND v(dout0_2) AT=1910.05n

* CHECK dout0_3 Vdout0_3ck190 = 0 time = 1910
.meas tran vdout0_3ck190 FIND v(dout0_3) AT=1910.05n

* CHECK dout0_4 Vdout0_4ck190 = 3.3 time = 1910
.meas tran vdout0_4ck190 FIND v(dout0_4) AT=1910.05n

* CHECK dout0_5 Vdout0_5ck190 = 3.3 time = 1910
.meas tran vdout0_5ck190 FIND v(dout0_5) AT=1910.05n

* CHECK dout0_6 Vdout0_6ck190 = 0 time = 1910
.meas tran vdout0_6ck190 FIND v(dout0_6) AT=1910.05n

* CHECK dout0_7 Vdout0_7ck190 = 3.3 time = 1910
.meas tran vdout0_7ck190 FIND v(dout0_7) AT=1910.05n

* CHECK dout0_0 Vdout0_0ck193 = 0 time = 1940
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=1940.05n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 1940
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=1940.05n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 1940
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=1940.05n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 1940
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=1940.05n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 1940
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=1940.05n

* CHECK dout0_5 Vdout0_5ck193 = 3.3 time = 1940
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=1940.05n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 1940
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=1940.05n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 1940
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=1940.05n

* CHECK dout0_0 Vdout0_0ck195 = 0 time = 1960
.meas tran vdout0_0ck195 FIND v(dout0_0) AT=1960.05n

* CHECK dout0_1 Vdout0_1ck195 = 0 time = 1960
.meas tran vdout0_1ck195 FIND v(dout0_1) AT=1960.05n

* CHECK dout0_2 Vdout0_2ck195 = 0 time = 1960
.meas tran vdout0_2ck195 FIND v(dout0_2) AT=1960.05n

* CHECK dout0_3 Vdout0_3ck195 = 0 time = 1960
.meas tran vdout0_3ck195 FIND v(dout0_3) AT=1960.05n

* CHECK dout0_4 Vdout0_4ck195 = 0 time = 1960
.meas tran vdout0_4ck195 FIND v(dout0_4) AT=1960.05n

* CHECK dout0_5 Vdout0_5ck195 = 3.3 time = 1960
.meas tran vdout0_5ck195 FIND v(dout0_5) AT=1960.05n

* CHECK dout0_6 Vdout0_6ck195 = 0 time = 1960
.meas tran vdout0_6ck195 FIND v(dout0_6) AT=1960.05n

* CHECK dout0_7 Vdout0_7ck195 = 0 time = 1960
.meas tran vdout0_7ck195 FIND v(dout0_7) AT=1960.05n

* CHECK dout0_0 Vdout0_0ck196 = 3.3 time = 1970
.meas tran vdout0_0ck196 FIND v(dout0_0) AT=1970.05n

* CHECK dout0_1 Vdout0_1ck196 = 0 time = 1970
.meas tran vdout0_1ck196 FIND v(dout0_1) AT=1970.05n

* CHECK dout0_2 Vdout0_2ck196 = 3.3 time = 1970
.meas tran vdout0_2ck196 FIND v(dout0_2) AT=1970.05n

* CHECK dout0_3 Vdout0_3ck196 = 0 time = 1970
.meas tran vdout0_3ck196 FIND v(dout0_3) AT=1970.05n

* CHECK dout0_4 Vdout0_4ck196 = 3.3 time = 1970
.meas tran vdout0_4ck196 FIND v(dout0_4) AT=1970.05n

* CHECK dout0_5 Vdout0_5ck196 = 3.3 time = 1970
.meas tran vdout0_5ck196 FIND v(dout0_5) AT=1970.05n

* CHECK dout0_6 Vdout0_6ck196 = 0 time = 1970
.meas tran vdout0_6ck196 FIND v(dout0_6) AT=1970.05n

* CHECK dout0_7 Vdout0_7ck196 = 3.3 time = 1970
.meas tran vdout0_7ck196 FIND v(dout0_7) AT=1970.05n

* CHECK dout0_0 Vdout0_0ck197 = 3.3 time = 1980
.meas tran vdout0_0ck197 FIND v(dout0_0) AT=1980.05n

* CHECK dout0_1 Vdout0_1ck197 = 0 time = 1980
.meas tran vdout0_1ck197 FIND v(dout0_1) AT=1980.05n

* CHECK dout0_2 Vdout0_2ck197 = 3.3 time = 1980
.meas tran vdout0_2ck197 FIND v(dout0_2) AT=1980.05n

* CHECK dout0_3 Vdout0_3ck197 = 0 time = 1980
.meas tran vdout0_3ck197 FIND v(dout0_3) AT=1980.05n

* CHECK dout0_4 Vdout0_4ck197 = 3.3 time = 1980
.meas tran vdout0_4ck197 FIND v(dout0_4) AT=1980.05n

* CHECK dout0_5 Vdout0_5ck197 = 3.3 time = 1980
.meas tran vdout0_5ck197 FIND v(dout0_5) AT=1980.05n

* CHECK dout0_6 Vdout0_6ck197 = 0 time = 1980
.meas tran vdout0_6ck197 FIND v(dout0_6) AT=1980.05n

* CHECK dout0_7 Vdout0_7ck197 = 3.3 time = 1980
.meas tran vdout0_7ck197 FIND v(dout0_7) AT=1980.05n

* CHECK dout0_0 Vdout0_0ck199 = 0 time = 2000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=2000.05n

* CHECK dout0_1 Vdout0_1ck199 = 3.3 time = 2000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=2000.05n

* CHECK dout0_2 Vdout0_2ck199 = 3.3 time = 2000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=2000.05n

* CHECK dout0_3 Vdout0_3ck199 = 3.3 time = 2000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=2000.05n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 2000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=2000.05n

* CHECK dout0_5 Vdout0_5ck199 = 3.3 time = 2000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=2000.05n

* CHECK dout0_6 Vdout0_6ck199 = 3.3 time = 2000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=2000.05n

* CHECK dout0_7 Vdout0_7ck199 = 0 time = 2000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=2000.05n

* CHECK dout0_0 Vdout0_0ck200 = 0 time = 2010
.meas tran vdout0_0ck200 FIND v(dout0_0) AT=2010.05n

* CHECK dout0_1 Vdout0_1ck200 = 3.3 time = 2010
.meas tran vdout0_1ck200 FIND v(dout0_1) AT=2010.05n

* CHECK dout0_2 Vdout0_2ck200 = 3.3 time = 2010
.meas tran vdout0_2ck200 FIND v(dout0_2) AT=2010.05n

* CHECK dout0_3 Vdout0_3ck200 = 3.3 time = 2010
.meas tran vdout0_3ck200 FIND v(dout0_3) AT=2010.05n

* CHECK dout0_4 Vdout0_4ck200 = 0 time = 2010
.meas tran vdout0_4ck200 FIND v(dout0_4) AT=2010.05n

* CHECK dout0_5 Vdout0_5ck200 = 3.3 time = 2010
.meas tran vdout0_5ck200 FIND v(dout0_5) AT=2010.05n

* CHECK dout0_6 Vdout0_6ck200 = 3.3 time = 2010
.meas tran vdout0_6ck200 FIND v(dout0_6) AT=2010.05n

* CHECK dout0_7 Vdout0_7ck200 = 0 time = 2010
.meas tran vdout0_7ck200 FIND v(dout0_7) AT=2010.05n

* CHECK dout0_0 Vdout0_0ck203 = 0 time = 2040
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=2040.05n

* CHECK dout0_1 Vdout0_1ck203 = 3.3 time = 2040
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=2040.05n

* CHECK dout0_2 Vdout0_2ck203 = 3.3 time = 2040
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=2040.05n

* CHECK dout0_3 Vdout0_3ck203 = 3.3 time = 2040
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=2040.05n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 2040
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=2040.05n

* CHECK dout0_5 Vdout0_5ck203 = 3.3 time = 2040
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=2040.05n

* CHECK dout0_6 Vdout0_6ck203 = 3.3 time = 2040
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=2040.05n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 2040
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=2040.05n

* CHECK dout0_0 Vdout0_0ck204 = 0 time = 2050
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=2050.05n

* CHECK dout0_1 Vdout0_1ck204 = 3.3 time = 2050
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=2050.05n

* CHECK dout0_2 Vdout0_2ck204 = 0 time = 2050
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=2050.05n

* CHECK dout0_3 Vdout0_3ck204 = 3.3 time = 2050
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=2050.05n

* CHECK dout0_4 Vdout0_4ck204 = 0 time = 2050
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=2050.05n

* CHECK dout0_5 Vdout0_5ck204 = 3.3 time = 2050
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=2050.05n

* CHECK dout0_6 Vdout0_6ck204 = 3.3 time = 2050
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=2050.05n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 2050
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=2050.05n

* probe is used for hspice/xa, while plot is used in ngspice
*.probe V(*)
*.plot V(*)
.end
